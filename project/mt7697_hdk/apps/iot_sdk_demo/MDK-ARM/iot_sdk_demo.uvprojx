# Keil uVision project iot_sdk_demo.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MT7687F MediaTek
  pack: MediaTek.MTx.4.6.2
  cpu: IROM(0x10000000,0x00200000) IRAM(0x20000000,0x00040000) IRAM2(0x00100000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: iot_sdk_demo +hex
  AfterMake: fromelf.exe --bin -o $L@L.bin #L
  AfterMake: fromelf.exe -c -o $L@L.dis #L
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: MBEDTLS_CONFIG_FILE=<config-mtk-basic.h>,MTK_BLE_SMTCN_ENABLE,__BT_DEBUG__,MTK_BT_LWIP_ENABLE,MTK_BLE_BQB_TEST_ENABLE,MTK_BLE_CLI_ENABLE,MTK_BLE_BQB_CLI_ENABLE,MTK_WIFI_REPEATER_ENABLE,MTK_HCI_CONSOLE_MIX_ENABLE,PCFG_OS=2 _REENT_SMALL MTK_MINISUPP_ENABLE MTK_MINICLI_ENABLE MTK_BSPEXT_ENABLE MTK_HAL_LOWPOWER_ENABLE MTK_LWIP_ENABLE MTK_HTTPCLIENT_SSL_ENABLE MTK_IPERF_ENABLE PRODUCT_VERSION=7687 MTK_FLASH_DIRECT_DL MTK_PATCH_DL_ENABLE   MTK_SMTCN_V5_ENABLE MTK_CLI_TEST_MODE_ENABLE MTK_WIFI_REPEATER_ENABLE  CONFIG_REPEATER MTK_DEBUG_LEVEL_INFO MTK_DEBUG_LEVEL_WARNING MTK_DEBUG_LEVEL_ERROR   CFG_SUPPORT_SMNT_PROTO=2 MTK_WIFI_PROFILE_ENABLE MTK_PING_OUT_ENABLE MTK_LOAD_MAC_ADDR_FROM_EFUSE MTK_NVDM_ENABLE MTK_WIFI_PRIVILEGE_ENABLE MTK_MCS_ENABLE MTK_BLE_GPIO_SERVICE
  c misc: --C99
  c include: ..\inc;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\kernel\rtos\FreeRTOS\inc;..\..\..\..\..\driver\CMSIS\Device\MTK\mt7687\Include;..\..\..\..\..\driver\CMSIS\Include;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\middleware\third_party\lwip\src\include;..\..\..\..\..\middleware\third_party\lwip\ports\include;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\driver\chip\mt7687\inc;..\..\..\..\..\middleware\MTK\wifi_service\combo\inc;..\..\..\..\..\middleware\MTK\dhcpd\inc;..\..\..\..\..\middleware\MTK\minicli\inc;..\..\..\..\..\middleware\MTK\minisupp\inc;..\..\..\..\..\prebuilt\middleware\MTK\minisupp\inc;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\driver\chip\mt7687\src\common\include;..\..\..\..\..\middleware\third_party\lwip\src\include;..\..\..\..\..\middleware\third_party\lwip\ports\include;..\..\..\..\..\middleware\third_party\lwip\src\include\lwip;..\..\..\..\..\project\common\bsp_ex\inc;..\..\..\..\..\middleware\MTK\nvdm\inc;..\..\..\..\..\middleware\third_party\ping\inc;..\..\..\..\..\middleware\MTK\smtcn\inc;..\..\..\..\..\middleware\MTK\smtcn\inc\internal;..\..\..\..\..\middleware\MTK\iperf\inc;..\..\..\..\..\driver\chip\mt7687\inc;..\..\..\..\..\driver\board\mt76x7_hdk\util\inc;..\..\..\..\..\middleware\MTK\wifi_service\combo\inc;..\src\ut_app;..\..\..\..\..\middleware\MTK\bluetooth\inc\;..\src_protected\bqb;..\..\..\..\..\middleware\MTK\bluetooth\inc;..\..\..\..\..\prebuilt\middleware\MTK\bluetooth\inc;..\..\..\..\..\middleware\MTK\ble_smtcn\inc;..\..\..\..\..\driver\board\mt76x7_hdk\ept\inc;..\..\..\..\..\middleware\third_party\mbedtls\include\;..\..\..\..\..\middleware\third_party\mbedtls\configs;..\..\..\..\..\driver\board\mt76x7_hdk\external_flash\inc;..\..\..\..\..\middleware\third_party\httpclient\inc;..\..\..\..\..\middleware\MTK\connsys\inc;..\..\..\..\..\middleware\MTK\verno\inc
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x100000 size 0x10000
  scatter file: .\flash.sct
  link misc: --entry Reset_Handler --first __isr_vector --keep N9_array
  group apps
    ../src/: main.c regions_init.c mcs.c system_mt7687.c ept_eint_var.c ept_gpio_var.c sys_init.c cli_cmds.c cli_def.c wifi_lwip_helper.c network_default_config.c nvdm_config.c wifi_nvdm_config.c
    ../../../../../driver/board/mt76x7_hdk/ept/src/: bsp_gpio_ept_config.c
    ../../../../../tools/keil/mt7687/N9/: mt76X7_n9_image.c
  group cmsis
    ./: startup_mt7687.s
  group rtos
    ../../../../../kernel/rtos/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/RVDS/mt7687/: port_tick.c
  group bsp
    ../../../../../middleware/MTK/wifi_service/combo/src/: wifi_cm4_scan.c wifi_repeater.c inband_queue_option.c get_profile_string.c misc.c wifi_inband_cli.c wifi_profile.c wifi_wps.c wifi_os_api.c wifi_cli.c
    ../../../../../middleware/MTK/wifi_service/combo/src/wifi_os_ext/: os_util.c os_utils.c
    ../../../../../middleware/MTK/wifi_service/combo/src/init/: wifi_init.c wifi_default_config.c
    ../../../../../prebuilt/middleware/MTK/wifi_service/combo/lib/wifi_supp/: libwifi_CM4_Keil.lib
    ../../../../../driver/board/mt76x7_hdk/util/src/: io_def.c board_cli.c gpio_cli.c
  group minisupp
    ../../../../../prebuilt/middleware/MTK/minisupp/lib/: libminisupp_CM4_Keil.lib
  group driver
    ../../../../../driver/chip/mt7687/src/: hal_misc.c hal_adc.c hal_aes.c hal_cache.c hal_cache_internal.c hal_des.c hal_eint.c hal_flash.c hal_gdma.c hal_gpio.c hal_gpt.c hal_i2c_master.c hal_i2s.c hal_irtx.c hal_log.c hal_md5.c hal_pwm.c hal_rtc.c hal_sha.c hal_spi_master.c hal_uart.c hal_wdt.c hal_nvic.c hal_dwt.c hal_nvic_internal.c
    ../../../../../driver/chip/mt7687/src/common/: cos_api.c dma.c flash_sfc.c gpt.c hal_gpc.c hal_gpio_7687.c hal_I2C.c hal_i2s_internal.c hal_irrx.c hal_lp.c hal_pcnt.c hal_pinmux.c hal_spim.c hal_sys.c hal_trng.c hal_uid.c i2c.c ir_tx.c low_hal_gpio.c low_hal_irrx.c low_hal_irtx.c low_hal_pwm.c low_hal_rtc.c low_hal_wdt.c nvic.c pinmux.c pwm.c sfc.c spi_flash.c spim.c timer.c top.c uart.c
    ../../../../../middleware/MTK/connsys/src/: connsys_util.c connsys_bus.c connsys_driver.c
    ../../../../../prebuilt/driver/chip/mt7687/lib/: libhal_core_CM4_Keil.lib libhal_protected_CM4_Keil.lib
    ../../../../../driver/board/mt76x7_hdk/external_flash/src/: bsp_flash_config.c
  group nvdm
    ../../../../../middleware/MTK/nvdm/src/: nvdm_port.c nvdm_cli.c
    ../../../../../prebuilt/middleware/MTK/nvdm/lib/: libnvdm_CM4_KEIL.lib
  group minicli
    ../../../../../prebuilt/middleware/MTK/minicli/lib/: libminicli_CM4_Keil.lib
    ../../../../../middleware/MTK/minicli/src/: minicli_api.c
  group lwip
    ../../../../../middleware/third_party/lwip/ports/: ethernetif.c lwip_cli.c lwip_log.c pbuf.c sys_arch.c tcp_out.c
    ../../../../../middleware/third_party/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c pppapi.c sockets.c tcpip.c
    ../../../../../middleware/third_party/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c ip_frag.c ip4.c ip4_addr.c
    ../../../../../middleware/third_party/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../../../middleware/third_party/lwip/src/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
    ../../../../../middleware/third_party/lwip/src/core/: def.c dhcp.c dns.c inet_chksum.c init.c mem.c memp.c netif.c raw.c stats.c sys.c tcp.c tcp_in.c udp.c lwip_timers.c
    ../../../../../middleware/third_party/lwip/src/netif/ppp/polarssl/: arc4.c des.c md4.c sha1.c md5.c
    ../../../../../middleware/third_party/lwip/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c ppp.c pppcrypt.c pppoe.c pppos.c upap.c vj.c utils.c
    ../../../../../middleware/third_party/lwip/src/netif/: etharp.c slipif.c
  group dhcpd
    ../../../../../middleware/MTK/dhcpd/src/: dhcpd.c
  group smtcn
    ../../../../../middleware/MTK/smtcn/src/: bsmtcn_ops.c ops_config.c smt_conn.c smt_api.c
    ../../../../../prebuilt/middleware/MTK/smtcn/lib/: libbcsmtcn_CM4_Keil.lib
  group mbedtls
    ../../../../../middleware/third_party/mbedtls/port/: porting_layer.c
    ../../../../../middleware/third_party/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c cmac.c ecjpake.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group httpclient
    ../../../../../middleware/third_party/httpclient/src/: httpclient.c
  group iperf
    ../../../../../middleware/MTK/iperf/src/: iperf_task.c iperf_cli.c
  group kservice
    ../../../../../kernel/service/src/: context_info_save.c exception_handler.c syslog.c toi.c os_cli.c os_port_callback.c syslog_cli.c
  group bspex
    ../../../../common/bsp_ex/src/: lp_ex_sleep.c
    ../../../../../middleware/MTK/wifi_service/combo/src/: wifi_private_cli.c
  group ble
    ../src/: hci_log.c bt_init.c ble_smtcn.c
    ../src/ut_app/: connection_info.c bt_gattc_connect.c bt_gattc_handle_op.c bt_gattc_srv.c ble_gpio_service.c ble_gpio_client.c gatt_command.c gatt_service.c ut_app.c ut_app_gap.c bt_lwip.c
    ../../../../../middleware/MTK/bluetooth/src/: bt_cli.c bt_debug.c bt_hci_log.c bt_os_layer_api.c bt_task.c
  group lib
    ../../../../../prebuilt/middleware/MTK/bluetooth/lib/: libble_CM4_keil.lib libbtdriver_7697_CM4_keil.lib libble_multi_adv_CM4_keil.lib
  group ping
    ../../../../../middleware/third_party/ping/src/: ping.c ping_cli.c
