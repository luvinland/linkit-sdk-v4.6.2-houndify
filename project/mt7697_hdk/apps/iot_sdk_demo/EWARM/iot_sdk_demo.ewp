# IAR project iot_sdk_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: MTK_LOAD_MAC_ADDR_FROM_EFUSE; MTK_PING_OUT_ENABLE; MTK_WIFI_PROFILE_ENABLE; PCFG_OS=2; _REENT_SMALL; MTK_MINISUPP_ENABLE; MTK_MINICLI_ENABLE; MTK_BSPEXT_ENABLE; MTK_HAL_LOWPOWER_ENABLE; MTK_LWIP_ENABLE; MTK_HTTPCLIENT_SSL_ENABLE; MTK_IPERF_ENABLE; PRODUCT_VERSION=7697; MTK_FLASH_DIRECT_DL; MTK_PATCH_DL_ENABLE; MTK_SMTCN_V5_ENABLE; MTK_CLI_TEST_MODE_ENABLE; MTK_WIFI_REPEATER_ENABLE; CONFIG_REPEATER; MTK_DEBUG_LEVEL_INFO; MTK_DEBUG_LEVEL_WARNING; MTK_DEBUG_LEVEL_ERROR; configOVERRIDE_DEFAULT_TICK_CONFIGURATION; CFG_SUPPORT_SMNT_PROTO=2; BT_DEBUG; MTK_BLE_CLI_ENABLE; MTK_BLE_BQB_CLI_ENABLE; MTK_HCI_CONSOLE_MIX_ENABLE; MTK_BLE_BQB_TEST_ENABLE; MTK_BLE_SMTCN_ENABLE; SUPPORT_MBEDTLS; MBEDTLS_CONFIG_FILE=<config-mtk-basic.h>; MTK_NVDM_ENABLE; MTK_WIFI_PRIVILEGE_ENABLE; MTK_MCS_ENABLE; MTK_BLE_GPIO_SERVICE; __BT_DEBUG__
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\kernel\rtos\FreeRTOS\inc; ..\..\..\..\..\driver\CMSIS\Device\MTK\mt7687\Include; ..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\chip\mt7687\inc; ..\..\..\..\..\middleware\MTK\wifi_service\combo\inc; ..\..\..\..\..\middleware\MTK\dhcpd\inc; ..\..\..\..\..\middleware\MTK\minicli\inc; ..\..\..\..\..\middleware\MTK\minisupp\inc; ..\..\..\..\..\prebuilt\middleware\MTK\minisupp\inc; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\chip\mt7687\src\common\include; ..\..\..\..\..\middleware\third_party\lwip\src\include; ..\..\..\..\..\middleware\third_party\lwip\ports\include; ..\..\..\..\..\middleware\third_party\lwip\src\include\lwip; ..\..\..\..\..\project\common\bsp_ex\inc; ..\..\..\..\..\middleware\MTK\nvdm\inc; ..\..\..\..\..\middleware\third_party\ping\inc; ..\..\..\..\..\middleware\MTK\smtcn\inc; ..\..\..\..\..\middleware\MTK\smtcn\inc\internal; ..\..\..\..\..\middleware\MTK\iperf\inc; ..\..\..\..\..\project\mt7697_hdk\apps\iot_sdk_demo\inc; ..\..\..\..\..\driver\chip\mt7687\inc; ..\..\..\..\..\driver\board\mt76x7_hdk\util\inc; ..\..\..\..\..\middleware\MTK\wifi_service\combo\inc; ..\..\..\..\..\middleware\MTK\bluetooth\inc; ..\..\..\..\..\prebuilt\middleware\MTK\bluetooth\inc; ..\..\..\..\..\project\mt7697_hdk\apps\iot_sdk_demo\src\ut_app; ..\..\..\..\..\driver\board\mt76x7_hdk\ept\inc; ..\..\..\..\..\middleware\third_party\mbedtls\include; ..\..\..\..\..\middleware\third_party\mbedtls\configs; ..\..\..\..\..\driver\board\mt76x7_hdk\external_flash\inc; ..\..\..\..\..\middleware\third_party\httpclient\inc; ..\..\..\..\..\middleware\MTK\connsys\inc; ..\..\..\..\..\middleware\MTK\verno\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: iot_sdk_demo.bin
  ILINK.IlinkOutputFile: iot_sdk_demo.out
  ILINK.IlinkKeepSymbols: __bootloader
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkExtraOptions: --redirect malloc=pvPortMalloc; --redirect calloc=pvPortCalloc; --redirect realloc=pvPortRealloc; --redirect free=vPortFree
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group apps
    ../../../../../middleware/third_party/mbedtls/library/: aes.c
    ../src/: ble_smtcn.c bt_init.c cli_cmds.c cli_def.c ept_eint_var.c ept_gpio_var.c hci_log.c main.c regions_init.c mcs.c sys_init.c network_default_config.c wifi_lwip_helper.c nvdm_config.c wifi_nvdm_config.c
    ../src/ut_app/: bt_lwip.c connection_info.c gatt_command.c gatt_service.c bt_gattc_connect.c bt_gattc_handle_op.c bt_gattc_srv.c ble_gpio_service.c ble_gpio_client.c ut_app.c ut_app_gap.c
  group ble
    ../../../../../middleware/MTK/bluetooth/src/: bt_cli.c bt_debug.c bt_hci_log.c bt_os_layer_api.c bt_task.c
    ../../../../../prebuilt/middleware/MTK/bluetooth/lib/: libble_iar.a libble_multi_adv_iar.a libbtdriver_7697_iar.a
  group bsp
    ../../../../../middleware/MTK/wifi_service/combo/src/: wifi_cm4_scan.c wifi_repeater.c inband_queue_option.c get_profile_string.c misc.c wifi_cli.c wifi_inband_cli.c wifi_os_api.c wifi_profile.c wifi_wps.c
    ../../../../../driver/board/mt76x7_hdk/util/src/: board_cli.c gpio_cli.c io_def.c
    ../../../../../driver/board/mt76x7_hdk/ept/src/: bsp_gpio_ept_config.c
    ../../../../../prebuilt/middleware/MTK/wifi_service/combo/lib/wifi_supp/: libwifi_CM4_IAR.a
    ../../../../../middleware/MTK/wifi_service/combo/src/wifi_os_ext/: os_util.c os_utils.c
    ../../../../../middleware/MTK/wifi_service/combo/src/init/: wifi_default_config.c wifi_init.c
  group bspex
    ../../../../common/bsp_ex/src/: lp_ex_sleep.c
    ../../../../../middleware/MTK/wifi_service/combo/src/: wifi_private_cli.c
  group cmsis
    ./: startup_mt7687.s
    ../src/: system_mt7687.c
  group dhcpd
    ../../../../../middleware/MTK/dhcpd/src/: dhcpd.c
  group driver
    ../../../../../driver/chip/mt7687/src/: hal_misc.c hal_adc.c hal_aes.c hal_cache.c hal_cache_internal.c hal_des.c hal_eint.c hal_flash.c hal_gdma.c hal_gpio.c hal_gpt.c hal_i2c_master.c hal_i2s.c hal_irtx.c hal_log.c hal_md5.c hal_nvic.c hal_dwt.c hal_nvic_internal.c hal_pwm.c hal_rtc.c hal_sha.c hal_spi_master.c hal_uart.c hal_wdt.c
    ../../../../../driver/board/mt76x7_hdk/external_flash/src/: bsp_flash_config.c
    ../../../../../middleware/MTK/connsys/src/: connsys_bus.c connsys_driver.c connsys_util.c
    ../../../../../driver/chip/mt7687/src/common/: cos_api.c dma.c flash_sfc.c gpt.c hal_gpc.c hal_gpio_7687.c hal_I2C.c hal_i2s_internal.c hal_irrx.c hal_lp.c hal_pcnt.c hal_pinmux.c hal_spim.c hal_sys.c hal_trng.c hal_uid.c i2c.c ir_tx.c low_hal_gpio.c low_hal_irrx.c low_hal_irtx.c low_hal_pwm.c low_hal_rtc.c low_hal_wdt.c nvic.c pinmux.c pwm.c sfc.c spi_flash.c spim.c timer.c top.c uart.c
    ../../../../../prebuilt/driver/chip/mt7687/lib/: libhal_core_CM4_IAR.a libhal_protected_CM4_IAR.a
  group iarfs
    $EW_DIR$/arm/src/lib/: close.c lseek.c open.c read.c remove.c write.c
  group mbedtls
    ../../../../../middleware/third_party/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c ecjpake.c cmac.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group httpclient
    ../../../../../middleware/third_party/httpclient/src/: httpclient.c
  group iperf
    ../../../../../middleware/MTK/iperf/src/: iperf_cli.c iperf_task.c
  group kernel
    ../../../../../kernel/service/src/: context_info_save.c exception_handler.c syslog.c toi.c
    ../../../../../kernel/rtos/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/IAR/mt7687/: port_tick.c
  group kservice
    ../../../../../kernel/service/src/: os_cli.c os_port_callback.c syslog_cli.c
  group lwip
    ../../../../../middleware/third_party/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c pppapi.c sockets.c tcpip.c
    ../../../../../middleware/third_party/lwip/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
    ../../../../../middleware/third_party/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c ppp.c pppcrypt.c pppoe.c pppos.c upap.c utils.c vj.c
    ../../../../../middleware/third_party/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c ip4.c ip4_addr.c ip_frag.c
    ../../../../../middleware/third_party/lwip/src/core/: def.c dhcp.c dns.c inet_chksum.c init.c lwip_timers.c mem.c memp.c netif.c raw.c stats.c sys.c tcp.c tcp_in.c udp.c
    ../../../../../middleware/third_party/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../../../middleware/third_party/lwip/src/netif/: etharp.c slipif.c
    ../../../../../middleware/third_party/lwip/ports/: ethernetif.c lwip_cli.c lwip_log.c pbuf.c sys_arch.c tcp_out.c
  group minicli
    ../../../../../prebuilt/middleware/MTK/minicli/lib/: libminicli_CM4_IAR.a
  group minisupp
    ../../../../../prebuilt/middleware/MTK/minisupp/lib/: libminisupp_CM4_IAR.a
  group N9
    ../../../../../tools/iar/mt7687/N9/: mt76X7_n9_image.c
  group nvdm
    ../../../../../prebuilt/middleware/MTK/nvdm/lib/: libnvdm_CM4_IAR.a
    ../../../../../middleware/MTK/nvdm/src/: nvdm_cli.c nvdm_port.c
  group ping
    ../../../../../middleware/third_party/ping/src/: ping.c ping_cli.c
  group smtcn
    ../../../../../middleware/MTK/smtcn/src/: bsmtcn_ops.c ops_config.c smt_api.c smt_conn.c
    ../../../../../prebuilt/middleware/MTK/smtcn/lib/: libbcsmtcn_CM4_IAR.a
