# IAR project headset_ref_design.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: MTK_DEBUG_LEVEL_INFO; MTK_DEBUG_LEVEL_WARNING; MTK_DEBUG_LEVEL_ERROR; PRODUCT_VERSION=2533; MTK_DEVELOPMENT_BOARD_EVB; configOVERRIDE_DEFAULT_TICK_CONFIGURATION; MTK_BT_AT_COMMAND_ENABLE; MTK_SMART_BATTERY_ENABLE; MTK_USB_DEMO_ENABLED; MTK_PORT_SERVICE_ENABLE; MTK_ATCI_VIA_PORT_SERVICE; __MTK_TARGET__; MBEDTLS_CONFIG_FILE=<config-mtk-md5.h>; __BT_DEBUG__; MTK_NVDM_ENABLE; MTK_OS_CPU_UTILIZATION_ENABLE; MTK_SYSTEM_AT_COMMAND_ENABLE; USE_EXTERNAL_BOOST; MTK_AUDIO_MP3_ENABLED; MTK_EXTERNAL_GAUGE; MTK_EXTERNAL_PMIC; MTK_EXTERNAL_DSP_ENABL; MTK_XOSC_MODE; MTK_BT_A2DP_AAC_ENABLE; MTK_BT_DUO_ENABLE; MTK_BT_CODEC_ENABLED; MTK_BT_ENABLE; MTK_BT_HFP_ENABLE; MTK_BT_AVRCP_ENABLE; MTK_BT_AVRCP_ENH_ENABLE; MTK_BT_A2DP_ENABLE; MTK_BT_PBAP_ENABLE; MTK_BT_SPP_ENABLE; MTK_BT_AWS_ENABLE; MTK_DEMO_PROJ_LOWPOWER_AT_CMD_ENABLE; __MUSIC_MODE_SWITCH_SUPPORT__; SCT_KEY_EVENT_ENABLE; MTK_KEYPAD_ENABLE; MTK_BT_A2DP_AAC_FEATURE_SW_DECODE; __HAL_AUDIO_AWS_SUPPORT__
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\driver\CMSIS\Device\MTK\mt2523\Include; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\chip\mt2523\inc; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\driver\board\component\common; ..\..\..\..\..\driver\board\component\lcm\ST7789H2; ..\..\..\..\..\prebuilt\middleware\MTK\bluetooth\inc; ..\..\..\..\..\middleware\MTK\nvdm\inc; ..\..\..\..\..\middleware\MTK\atci\inc; ..\..\..\..\..\driver\board\mt25x3_hdk\lcd; ..\..\..\..\..\driver\board\component\mems\inc; ..\..\..\..\..\driver\board\component\mems\src\libyas533\inc; ..\..\..\..\..\driver\board\mt25x3_hdk\backlight; ..\..\..\..\..\driver\board\mt25x3_hdk\keypad\inc; ..\..\..\..\..\middleware\MTK\nvdm\inc; ..\..\..\..\..\middleware\MTK\nvdm\src\nvdm_internal.h; ..\..\..\..\..\middleware\MTK\nvdm\src\portable; ..\..\..\..\..\driver\board\mt25x3_hdk\bt_codec\inc; ..\..\..\..\..\prebuilt\middleware\MTK\fuelgauge\inc; ..\..\..\..\..\middleware\MTK\battery_management\port\mt2533\inc; ..\..\..\..\..\middleware\MTK\battery_management\inc; ..\..\..\..\..\driver\board\component\touch_panel\ctp_goodix_gt9xxx\gt9137; ..\..\..\..\..\prebuilt\driver\board\component\bt_codec\inc; ..\..\..\..\..\driver\board\component\touch_panel\common\inc; ..\..\..\..\..\driver\board\mt25x3_hdk\touch_panel\gt9137; ..\..\..\..\..\driver\board\mt25x3_hdk\touch_panel\it7258; ..\..\..\..\..\driver\board\mt25x3_hdk\touch_panel\config; ..\..\..\..\..\driver\board\component\touch_panel\ctp_ite_it7xxx\it7258; ..\..\..\..\..\driver\board\component\biosensor\mt2511\inc; ..\..\..\..\..\driver\board\component\biosensor\mt2511\module\default; ..\..\..\..\..\driver\board\component\biosensor\mt2511\module\everlight; ..\..\..\..\..\middleware\MTK\nvdm\inc_core; ..\..\..\..\..\prebuilt\middleware\MTK\nvdm\inc; ..\..\..\..\..\middleware\third_party\kiss_fft; ..\..\..\..\..\middleware\MTK\port_service\inc; ..\..\..\..\..\middleware\MTK\usb\inc; ..\..\..\..\..\driver\board\mt25x3_hdk\ept\inc; ..\..\..\..\..\middleware\third_party\kiss_fft; ..\..\..\..\..\middleware\MTK\sink\inc; ..\..\..\..\..\middleware\third_party\mbedtls\include; ..\..\..\..\..\middleware\third_party\mbedtls\include\mbedtls; ..\..\..\..\..\middleware\third_party\mbedtls\configs; ..\..\..\..\..\middleware\MTK\bt_callback_manager\inc; ..\..\..\..\..\middleware\MTK\gdi\inc; ..\..\..\..\..\driver\board\mt25x3_hdk\mems_init; ..\..\..\..\..\middleware\MTK\bluetooth_service\inc; ..\..\..\..\..\middleware\MTK\battery_management\inc; ..\..\..\..\..\middleware\MTK\battery_management\port\mt2533\inc; ..\..\..\..\..\middleware\MTK\bt_notify\inc; ..\..\..\..\..\middleware\MTK\bt_notify\inc\dogp; ..\..\..\..\..\driver\board\mt25x3_hdk\bootloader\core\inc; ..\..\..\..\..\driver\board\component\external_dsp\inc; ..\..\..\..\..\driver\board\component\pmic\MAX14745; ..\..\..\..\..\driver\board\component\pmic; ..\inc\AudioPlayer; ..\inc\ble_ancs_ios_notification; ..\inc\ble_bas_app; ..\inc\fota; ..\inc\notification; ..\inc\sink; ..\inc\ble_find_me_server; ..\..\..\..\..\middleware\MTK\audio\inc; ..\..\..\..\..\middleware\MTK\audio\mp3_codec\inc; ..\..\..\..\..\middleware\MTK\audio\port\mt2533\inc; ..\..\..\..\..\middleware\MTK\audio\port\mt2533\inc\mt2533_external_dsp_profile; ..\..\..\..\..\middleware\MTK\ble_ancs\inc; ..\..\..\..\..\prebuilt\middleware\MTK\ble_ancs\inc; ..\..\..\..\..\middleware\MTK\ble_bas\inc; ..\..\..\..\..\middleware\MTK\ble_ias\inc; ..\..\..\..\..\driver\board\component\gauge\max17048; ..\..\..\..\..\driver\board\component\mems\inc\libyas533; ..\..\..\..\..\middleware\MTK\sensor_subsys\inc; ..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\blood_pressure\inc; ..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\common\inc; ..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\heart_rate\inc; ..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\heart_rate_variability\inc; ..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\pedometer\inc; ..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\ppg_control\inc; ..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\sleep_tracker\inc; ..\..\..\..\..\driver\board\component\mems\inc; ..\..\..\..\..\middleware\MTK\fota\inc; ..\..\..\..\..\prebuilt\driver\board\component\audio\inc; ..\..\..\..\..\middleware\MTK\key_event\common\inc; ..\..\..\..\..\middleware\MTK\key_event\eint_key\inc; ..\..\..\..\..\middleware\MTK\key_event\keypad\inc; ..\..\..\..\..\driver\board\mt25x3_hdk\keypad\inc; ..\..\..\..\..\middleware\MTK\audio_manager\inc; ..\..\..\..\..\middleware\MTK\sink\inc\audio_file_manager; ..\..\..\..\..\middleware\third_party\fatfs\src; ..\inc\AudioPlayer\audio_file_manager; ..\..\..\..\..\middleware\MTK\audio\inc; ..\..\..\..\..\driver\chip\mt2523\inc; ..\..\..\..\..\middleware\MTK\verno\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: headset_ref_design.bin
  ILINK.IlinkOutputFile: freertos_thread_creation.out
  ILINK.IlinkKeepSymbols: __bootloader
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkExtraOptions: --redirect malloc=pvPortMalloc; --redirect calloc=pvPortCalloc; --redirect realloc=pvPortRealloc; --redirect free=vPortFree
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../src/: atci_cmd.c battery_message.c bt_app_common.c bt_gattc_discovery.c bt_init.c ept_eint_var.c ept_gpio_var.c gatt_service.c hci_log.c main.c regions_init.c task_def.c
  group app/AudioPlayer
    ../src/AudioPlayer/audio_file_manager/: audio_file_manager.c ucs2_util.c
    ../src/AudioPlayer/: audio_player_main.c
  group app/ble_ancs_ios_notification
    ../src/ble_ancs_ios_notification/: ble_ancs_app.c bt_ancs_common.c
  group app/ble_bas_app
    ../src/ble_bas_app/: ble_bas_app.c
  group app/ble_find_me_server
    ../src/ble_find_me_server/: ble_find_me_server.c
  group app/fota
    ../src/fota/: fota_bt_common.c fota_main.c
  group app/low_power_demo
    ../src/low_power_demo/: bt_at_cmd.c local_at_cmd.c sleep_at_cmd.c
  group app/Notification
    ../src/Notification/: bt_notify_app.c
  group app/pmic_port
    ../src/pmic_port/max14745/: external_pmic_port.c
  group app/sink
    ../src/sink/: bt_sink_app_cmd.c bt_sink_app_event.c bt_sink_app_keypad.c bt_sink_app_main.c
  group at_cmd
    ../../../../../middleware/MTK/atci/at_command/: at_command.c at_command_audio.c at_command_backlight.c at_command_biogui.c at_command_bt.c at_command_bt_testbox.c at_command_calibration_capid.c at_command_camera.c at_command_charger.c at_command_clock.c at_command_crypto.c at_command_ctp.c at_command_ctp_simulate.c at_command_dvfs.c at_command_external_gauge.c at_command_external_pmu.c at_command_gpio.c at_command_keypad.c at_command_keypad_simulate.c at_command_lcm.c at_command_led.c at_command_mem.c at_command_msdc.c at_command_nvdm.c at_command_pmu.c at_command_reg.c at_command_rtc.c at_command_serial_port.c at_command_sleep_manager.c at_command_syslog.c at_command_system.c at_command_testframework.c at_command_vibrator.c at_command_wdt.c
    ../../../../../middleware/third_party/kiss_fft/: kiss_fft.c
  group atci
    ../../../../../middleware/MTK/atci/src/: atci_adapter.c atci_handler.c atci_main.c
  group audio
    ../../../../../middleware/MTK/audio/src/: audio_codec.c audio_dsp_fd216_db_to_gain_value_mapping_table.c audio_middleware_api.c
    ../../../../../middleware/MTK/audio/port/mt2533/src/: audio_nvdm.c
    ../../../../../prebuilt/middleware/MTK/audio/mp3_codec/lib/arm_cm4/: lib_mp3dec_CM4_IAR.a
    ../../../../../middleware/MTK/audio/mp3_codec/src/: mp3_codec.c
  group audio_manager
    ../../../../../middleware/MTK/audio_manager/src/: audio_src_srv.c audio_src_srv_state_mgr.c
  group battery_management
    ../../../../../middleware/MTK/battery_management/port/mt2533/src/: battery.c
    ../../../../../middleware/MTK/battery_management/src/: battery_management.c
  group ble_ancs
    ../../../../../prebuilt/middleware/MTK/ble_ancs/lib/: libbleancs_IAR.a
  group ble_bas
    ../../../../../middleware/MTK/ble_bas/src/: ble_bas.c
  group ble_ias
    ../../../../../middleware/MTK/ble_ias/src/: ble_ias.c
  group bluetooth
    ../../../../../middleware/MTK/bluetooth/src/: bt_debug.c bt_hci_log.c bt_os_layer_api.c bt_task.c bt_timer_external.c
    ../../../../../prebuilt/middleware/MTK/bluetooth/lib/: libbt_a2dp_iar.a libbt_avrcp_enhance_iar.a libbt_avrcp_iar.a libbt_aws_iar.a libbt_driver_2523_iar.a libbt_hfp_iar.a libbt_iar.a libbt_pbapc_iar.a libbt_spp_iar.a
  group bluetooth_service
    ../../../../../middleware/MTK/bluetooth_service/src/: bt_device_manager.c bt_device_manager_le.c bt_gatts_service.c
  group board
    ../../../../../driver/board/mt25x3_hdk/bootloader/core/src/: bl_dbgprint.c bl_sd.c bl_uart.c
    ../../../../../driver/board/component/touch_panel/common/src/: bsp_ctp.c ctp.c ctp_i2c.c
    ../../../../../driver/board/mt25x3_hdk/ept/src/: bsp_gpio_ept_config.c
    ../../../../../driver/board/mt25x3_hdk/bt_codec/src/: bt_a2dp_codec.c bt_hfp_codec.c
    ../../../../../driver/board/component/touch_panel/ctp_goodix_gt9xxx/gt9137/: ctp_goodix_gt9xxx.c
    ../../../../../driver/board/component/touch_panel/ctp_ite_it7xxx/it7258/: ctp_ite_it7xxx.c ctp_ite_it7xxx_download.c
    ../../../../../middleware/third_party/fatfs/src/portable/mt2533/bootloader/src/: diskio.c
    ../../../../../driver/board/component/external_dsp/src/: external_dsp_application.c external_dsp_driver.c
    ../../../../../driver/board/component/gauge/max17048/: external_ntc.c max17048.c max17048_driver.c
    ../../../../../driver/board/component/pmic/: external_pmic_driver.c
    ../../../../../middleware/third_party/fatfs/src/: ff.c
    ../../../../../driver/board/mt25x3_hdk/gnss/: gnss_config.c
    ../../../../../driver/board/mt25x3_hdk/keypad/src/: keypad_custom.c
    ../../../../../driver/board/component/lcm/ST7789H2/: lcd.c
    ../../../../../driver/board/component/lcm/RM69032/: lcd_RM69032.c
    ../../../../../driver/board/mt25x3_hdk/backlight/: mt25x3_hdk_backlight.c
    ../../../../../driver/board/mt25x3_hdk/lcd/: mt25x3_hdk_lcd.c
    ../../../../../driver/board/component/pmic/MAX14745/: pmic_max14745.c
    ../../../../../driver/board/mt25x3_hdk/touch_panel/gt9137/: touch_panel_custom_goodix.c
    ../../../../../driver/board/mt25x3_hdk/touch_panel/it7258/: touch_panel_custom_ite.c
  group bt_callback_manager
    ../../../../../middleware/MTK/bt_callback_manager/src/: bt_callback_manager.c
  group bt_notify
    ../../../../../middleware/MTK/bt_notify/src/dogp/: ble_dogp_adp_service.c ble_dogp_common.c ble_dogp_service.c
    ../../../../../middleware/MTK/bt_notify/src/: bt_notify_conversion.c bt_notify_data_parse.c bt_notify_list.c bt_notify_task.c xml_main.c
    ../../../../../prebuilt/middleware/MTK/bt_notify/lib/: libbtnotify_IAR.a
  group cmsis
    ./: startup_mt2533.s
    ../src/: system_mt2533.c
  group common_lib
    ../../../../../prebuilt/driver/board/component/audio/lib/arm_cm4/: libblisrc_CM4_IAR.a
    ../../../../../prebuilt/driver/board/component/bt_codec/lib/arm_cm4/: libcvsd_codec_CM4_IAR.a libmsbc_codec_CM4_IAR.a libplc_CM4_IAR.a
    ../../../../../prebuilt/middleware/MTK/fuelgauge/lib/: libfgauge_IAR.a
    ../../../../../prebuilt/driver/chip/mt2523/lib/: libhal_core_CM4_IAR.a libhal_protected_CM4_IAR.a
  group driver
    ../../../../../driver/chip/mt2523/src/: hal_accdet.c hal_accdet_internal.c hal_adc.c hal_audio.c hal_audio_custom.c hal_audio_enhancement.c hal_audio_ext.c hal_audio_fw_interface.c hal_audio_fw_slt.c hal_audio_internal_afe.c hal_audio_internal_pcm.c hal_audio_internal_pcm2way.c hal_audio_internal_service.c hal_audio_internal_vm.c hal_audio_low_power.c hal_audio_post_processing.c hal_audio_test.c hal_bsi.c hal_cache.c hal_cache_internal.c hal_charger.c hal_clock_internal.c hal_dac.c hal_dcm.c hal_dcxo.c hal_display_color.c hal_display_color_internal.c hal_display_dsi.c hal_display_dsi_internal.c hal_display_lcd.c hal_display_lcd_internal.c hal_display_pwm.c hal_display_pwm_internal.c hal_dvfs.c hal_dvfs_internal.c hal_dvfs_internal_vcore.c hal_dwt.c hal_eint.c hal_eint_internal.c hal_emi.c hal_flash_cfi.c hal_flash_combo_init.c hal_flash_combo_nor.c hal_flash_custom.c hal_flash_custom_sfi.c hal_flash_disk.c hal_flash_mtd.c hal_flash_mtd_common.c hal_flash_mtd_dal.c hal_g2d.c hal_gdma.c hal_gdma_internal.c hal_gpio.c hal_gpt.c hal_gpt_internal.c hal_i2c_master.c hal_i2c_master_internal.c hal_i2c_pmic.c hal_i2s.c hal_i2s_internal.c hal_i2s_internal_pcm_route.c hal_isink.c hal_keypad.c hal_keypad_internal.c hal_keypad_powerkey_internal.c hal_log.c hal_misc.c hal_mpu.c hal_mpu_internal.c hal_msdc.c hal_nvic.c hal_nvic_internal.c hal_pdma_internal.c hal_pmu.c hal_pmu_auxadc.c hal_pmu_internal.c hal_pmu_wrap_interface.c hal_pwm.c hal_rtc.c hal_sd.c hal_sd_internal.c hal_sdio.c hal_sdio_internal.c hal_spi_master.c hal_spi_master_internal.c hal_spi_slave.c hal_spi_slave_internal.c hal_trng.c hal_trng_internal.c hal_uart.c hal_uart_internal.c hal_uart_internal_platform.c hal_usb.c hal_usb_phy.c hal_wdt.c hal_wdt_internal.c hal_wdt_retention.c hal_weak.c
  group fota
    ../../../../../middleware/MTK/fota/src/: fota.c
  group kernel
    ../../../../../kernel/service/src/: context_info_save.c exception_handler.c os_port_callback.c syslog.c toi.c
    ../../../../../kernel/rtos/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/GCC/mt2523/: port_tick.c
  group key_event
    ../../../../../middleware/MTK/key_event/eint_key/src/: sct_eint_key.c
    ../../../../../middleware/MTK/key_event/common/src/: sct_key_event.c sct_key_event_internal.c
    ../../../../../middleware/MTK/key_event/keypad/src/: sct_keypad.c
  group mems
    ../../../../../driver/board/component/mems/src/: bma255_i2c_operation.c bma255_sensor_adaptor.c bma2x2.c mems_bus.c sensor_manager_driver.c
    ../../../../../driver/board/mt25x3_hdk/mems_init/: mems_init.c
    ../../../../../driver/board/component/biosensor/mt2511/src/: vsm_driver.c vsm_i2c_operation.c vsm_platform_function.c vsm_sensor_subsys_adaptor.c vsm_spi_operation.c
  group nvdm
    ../../../../../prebuilt/middleware/MTK/nvdm/lib/: libnvdm_CM4_IAR.a
    ../../../../../middleware/MTK/nvdm/src/: nvdm_port.c
  group port_service
    ../../../../../middleware/MTK/port_service/src/: serial_port.c serial_port_para.c serial_port_uart.c serial_port_usb.c
    ../../../../../middleware/MTK/usb/src/_common/: usb.c usb_custom.c usb_main.c usb_resource.c
    ../../../../../middleware/MTK/usb/src/cdc/: usbacm_adap.c usbacm_drv.c
  group sink_middleware
    ../../../../../middleware/MTK/sink/src/: bt_sink_srv.c bt_sink_srv_a2dp.c bt_sink_srv_a2dp_callback.c bt_sink_srv_a2dp_state_machine.c bt_sink_srv_action.c bt_sink_srv_am_task.c bt_sink_srv_ami.c bt_sink_srv_atci_cmd.c bt_sink_srv_audio_setting.c bt_sink_srv_audio_sync.c bt_sink_srv_audio_tunning.c bt_sink_srv_avrcp.c bt_sink_srv_aws.c bt_sink_srv_aws_a2dp.c bt_sink_srv_aws_mp3.c bt_sink_srv_aws_system.c bt_sink_srv_common.c bt_sink_srv_config.c bt_sink_srv_conmgr.c bt_sink_srv_custom_db.c bt_sink_srv_db.c bt_sink_srv_hf.c bt_sink_srv_hf_call_manager.c bt_sink_srv_hf_multipoint.c bt_sink_srv_hf_pesudo_dev.c bt_sink_srv_media_mgr.c bt_sink_srv_mp3.c bt_sink_srv_mp3_state_machine.c bt_sink_srv_music.c bt_sink_srv_pbapc.c bt_sink_srv_spp.c bt_sink_srv_state_notify.c bt_sink_srv_utils.c sink_srv_util.c
  group third_party
    ../../../../../middleware/third_party/mbedtls/library/: aes.c md5.c
