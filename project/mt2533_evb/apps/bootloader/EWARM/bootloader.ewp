# IAR project bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BL_DEBUG; BL_LOAD_ENABLE; BL_FOTA_ENABLE; __UBL__; __EXT_BOOTLOADER__; MBEDTLS_CONFIG_FILE=<config-mtk-sha1.h>; BL_LOG_VIA_UART0; MTK_EXTERNAL_PMIC_TYPE_MT6327
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023,Pa082
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\driver\CMSIS\Device\MTK\mt2523\Include; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\chip\mt2523\inc; ..\..\..\..\..\driver\board\mt25x3_hdk\bootloader\core\inc; ..\..\..\..\..\driver\board\mt25x3_hdk\emi\inc; ..\inc; ..\..\..\..\..\middleware\third_party\mbedtls\include; ..\..\..\..\..\middleware\third_party\mbedtls\configs; ..\..\..\..\..\middleware\third_party\lzma_decoder\inc; ..\..\..\..\..\driver\board\mt25x3_hdk\bootloader\core\inc\pmic; ..\..\..\..\..\middleware\third_party\fatfs\src; ..\..\..\..\..\middleware\MTK\verno\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bootloader.bin
  ILINK.IlinkOutputFile: bootloader.out
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release-Flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  ILINK.IlinkKeepSymbols: __vector_table
  ILINK.IlinkIcfFile: mtk2523_flash.icf
  group bootloader
    ../../../../../driver/board/mt25x3_hdk/bootloader/core/src/: bl_clock.c bl_dbgprint.c bl_dcxo_cal.c bl_fota.c bl_gpt.c bl_main.c bl_misc.c bl_msdc.c bl_pmic.c bl_sd.c bl_sd_internal.c bl_uart.c bl_usb.c bl_wdt.c custom_blconfig.c
    ../../../../../driver/board/mt25x3_hdk/bootloader/core/src/pmic/: bl_max14745.c bl_mt6327.c bl_mt6385.c
    ./: startup_mt2523.s
  group emi
    ../../../../../driver/board/mt25x3_hdk/emi/src/: emi_init.c memory_test.c
  group fatfs
    ../../../../../middleware/third_party/fatfs/src/portable/mt2523/bootloader/src/: diskio.c
    ../../../../../middleware/third_party/fatfs/src/: ff.c
    ../../../../../middleware/third_party/fatfs/src/option/: syscall.c unicode.c
  group flash
    ../../../../../driver/chip/mt2523/src/: hal_flash_cfi.c hal_flash_combo_init.c hal_flash_combo_nor.c hal_flash_custom.c hal_flash_custom_sfi.c hal_flash_disk.c hal_flash_mtd.c hal_flash_mtd_common.c hal_flash_mtd_dal.c hal_cache.c hal_cache_internal.c hal_nvic_internal.c
  group hal
    ../../../../../driver/chip/mt2523/src/: hal_log.c
  group i2c
    ../../../../../driver/chip/mt2523/src/: hal_i2c_master_internal.c hal_i2c_pmic.c
  group lzma_decoder
    ../../../../../middleware/third_party/lzma_decoder/src/: lzma_decode_interface.c lzma_decoder.c
  group release_flash
    ./: main.c
  group sha1
    ../../../../../middleware/third_party/mbedtls/library/: sha1.c
