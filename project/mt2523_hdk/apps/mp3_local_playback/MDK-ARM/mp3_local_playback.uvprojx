# Keil uVision project mp3_local_playback.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MT2523x MediaTek
  pack: MediaTek.MTx.4.6.2
  cpu: IROM(0x08000000,0x00400000) IRAM(0x00000000,0x00400000) IRAM2(0x04008000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mp3_local_playback +hex
  AfterMake: fromelf.exe --bin -o $L@L.bin #L
  AfterMake: fromelf.exe -c -o $L@L.dis #L
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: PRODUCT_VERSION=2523 MTK_DEBUG_LEVEL_INFO MTK_DEVELOPMENT_BOARD_HDK MTK_SMART_BATTERY_ENABLE __BT_DEBUG__ MTK_NVDM_ENABLE MBEDTLS_CONFIG_FILE=<config-mtk-md5.h>  MTK_AUDIO_MP3_ENABLED MTK_PORT_SERVICE_ENABLE MTK_ATCI_VIA_PORT_SERVICE MTK_USB_DEMO_ENABLED
  c misc: --c99 --diag_suppress=161 --diag_suppress=1295
  c include: ..\inc;..\..\..\..\..\driver\CMSIS\Device\MTK\mt2523\Include;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\driver\chip\mt2523\inc;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\driver\CMSIS\Include;..\..\..\..\..\driver\chip\mt2523\src\common\include;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\driver\CMSIS\Include;..\..\..\..\..\driver\board\component\common;..\..\..\..\..\driver\board\component\lcm\ST7789H2;..\inc\bt_audio;..\inc\bt_audio\sink;..\..\..\..\..\middleware\MTK\bluetooth\inc;..\..\..\..\..\prebuilt\middleware\MTK\bluetooth\inc;..\..\..\..\..\middleware\MTK\nvdm\inc;..\inc\graphicLib;..\..\..\..\..\middleware\MTK\atci\inc;..\inc\gnss_screen;..\inc\pxp_screen;..\inc\sensor_demo;..\inc\watch_face;..\..\..\..\..\driver\board\mt25x3_hdk\lcd;..\..\..\..\..\middleware\MTK\sensor_subsys\inc;..\..\..\..\..\driver\board\component\mems\inc;..\..\..\..\..\driver\board\component\mems\inc\libyas533;..\..\..\..\..\middleware\MTK\gnss\inc;..\..\..\..\..\driver\board\mt25x3_hdk\backlight;..\..\..\..\..\middleware\MTK\audio\inc;..\..\..\..\..\driver\board\component\biosensor\mt2511\inc;..\..\..\..\..\middleware\MTK\nvdm\inc;..\..\..\..\..\middleware\MTK\nvdm\src\nvdm_internal.h;..\..\..\..\..\middleware\MTK\nvdm\src\portable;..\..\..\..\..\driver\board\mt25x3_hdk\bt_codec\inc;..\..\..\..\..\driver\board\mt25x3_hdk\lcd;..\..\..\..\..\middleware\MTK\gnss\inc;..\..\..\..\..\driver\board\component\biosensor\mt2511\inc;..\..\..\..\..\driver\board\component\touch_panel\common\inc;..\..\..\..\..\middleware\MTK\audio\inc;..\..\..\..\..\driver\board\component\touch_panel\ctp_goodix_gt9xxx\gt9137;..\..\..\..\..\prebuilt\driver\board\component\bt_codec\inc;..\..\..\..\..\driver\board\mt25x3_hdk\touch_panel\gt9137;..\..\..\..\..\driver\board\component\biosensor\mt2511\module\default;..\..\..\..\..\driver\board\mt25x3_hdk\backlight;..\..\..\..\..\driver\board\component\mems\inc;..\..\..\..\..\driver\board\component\lcm\ST7789H2;..\..\..\..\..\driver\board\component\touch_panel\ctp_goodix_gt9xxx\gt9137;..\..\..\..\..\middleware\MTK\battery_management\inc;..\..\..\..\..\middleware\MTK\battery_management\port\mt2523\inc;..\..\..\..\..\prebuilt\middleware\MTK\fuelgauge\inc;..\..\..\..\..\driver\board\mt76x7_hdk\init\inc;..\..\..\..\..\driver\board\component\biosensor\mt2511\inc;..\..\..\..\..\driver\board\component\biosensor\mt2511\module\default;..\..\..\..\..\driver\board\component\biosensor\mt2511\module\everlight;..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\agc\inc\;..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\common\inc\;..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\heart_rate\inc\;..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\heart_rate_variability\inc\;..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\ppg_control\inc\;..\..\..\..\..\driver\board\mt25x3_hdk\keypad\inc;..\..\..\..\..\driver\board\component\touch_panel\ctp_ite_it7xxx\it7258;..\..\..\..\..\driver\board\mt25x3_hdk\touch_panel\it7258;..\..\..\..\..\driver\board\mt25x3_hdk\ept\inc;..\..\..\..\..\middleware\third_party\kiss_fft;..\..\..\..\..\middleware\MTK\usb\inc;..\..\..\..\..\middleware\MTK\port_service\inc;..\..\..\..\..\middleware\MTK\bt_sink\inc;..\..\..\..\..\middleware\third_party\mbedtls\include;..\..\..\..\..\middleware\third_party\mbedtls\include\mbedtls;..\..\..\..\..\middleware\third_party\mbedtls\configs;..\inc\AudioPlayer;..\..\..\..\..\middleware\third_party\fatfs\src;..\..\..\..\..\middleware\MTK\bt_callback_manager\inc;..\..\..\..\..\middleware\MTK\bt_sink\inc;..\..\..\..\..\middleware\MTK\atci\inc;..\..\..\..\..\middleware\MTK\audio\mp3_codec\inc;..\..\..\..\..\driver\board\mt25x3_hdk\msdc\inc;..\..\..\..\..\middleware\MTK\port_service\inc;..\..\..\..\..\middleware\MTK\usb\inc;..\..\..\..\..\middleware\MTK\bluetooth_service\inc;..\..\..\..\..\middleware\MTK\audio\port\mt2523\inc;..\..\..\..\..\middleware\third_party\fatfs\src\portable\mt2523\inc;..\..\..\..\..\middleware\MTK\verno\inc;..\..\..\..\..\middleware\MTK\audio\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT9: RAM 0x0 size 0x400000
  memory RVCT10: RAM 0x4008000 size 0x20000
  scatter file: .\flash.sct
  link misc: --entry Reset_Handler --first __Vectors --debug
  group app
    ../src/: main.c regions_init.c ept_eint_var.c ept_gpio_var.c bt_init.c sys_init.c battery_message.c hci_log.c task_def.c
    ../src/AudioPlayer/: audio_player_main.c
  group cmsis
    ../src/: system_mt2523.c
    ./: startup_mt2523.s
  group kernel
    ../../../../../kernel/rtos/FreeRTOS/Source/: timers.c list.c queue.c tasks.c event_groups.c croutine.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/RVDS/mt2523/: port_tick.c
  group lib
    ../../../../../prebuilt/driver/chip/mt2523/lib/: libhal_protected_CM4_Keil.lib libhal_core_CM4_Keil.lib libcryptos_CM4_Keil.lib
    ../../../../../prebuilt/middleware/MTK/bluetooth/lib/: libbt_CM4_keil.lib libbtdriver_2523_CM4_keil.lib libbt_a2dp_CM4_keil.lib libbt_hfp_CM4_keil.lib libbt_avrcp_CM4_keil.lib libbt_spp_CM4_keil.lib libbt_pbapc_CM4_keil.lib
    ../../../../../prebuilt/middleware/MTK/fuelgauge/lib/: libfgauge.lib
    ../../../../../prebuilt/middleware/MTK/audio/mp3_codec/lib/arm_cm4/: lib_mp3dec_CM4_Keil.lib
    ../../../../../prebuilt/driver/board/component/bt_codec/lib/arm_cm4/: libcvsd_codec_CM4_Keil.lib libmsbc_codec_CM4_Keil.lib libplc_CM4_Keil.lib
  group nvdm
    ../../../../../middleware/MTK/nvdm/src/: nvdm_port.c
    ../../../../../prebuilt/middleware/MTK/nvdm/lib/: libnvdm_CM4_KEIL.lib
  group board
    ../../../../../driver/board/mt25x3_hdk/lcd/: mt25x3_hdk_lcd.c
    ../../../../../driver/board/mt25x3_hdk/gnss/: gnss_config.c
    ../../../../../driver/board/mt25x3_hdk/backlight/: mt25x3_hdk_backlight.c
    ../../../../../driver/board/component/lcm/ST7789H2/: lcd.c
    ../../../../../driver/board/component/touch_panel/ctp_goodix_gt9xxx/gt9137/: ctp_goodix_gt9xxx.c
    ../../../../../driver/board/mt25x3_hdk/keypad/src/: keypad_custom.c
    ../../../../../driver/board/mt25x3_hdk/touch_panel/it7258/: touch_panel_custom_ite.c
    ../../../../../driver/board/mt25x3_hdk/touch_panel/gt9137/: touch_panel_custom_goodix.c
    ../../../../../driver/board/component/touch_panel/ctp_ite_it7xxx/it7258/: ctp_ite_it7xxx.c ctp_ite_it7xxx_download.c
    ../../../../../driver/board/mt25x3_hdk/ept/src/: bsp_gpio_ept_config.c
    ../../../../../driver/board/component/lcm/RM69032/: lcd_RM69032.c
    ../../../../../driver/board/component/touch_panel/common/src/: bsp_ctp.c ctp.c ctp_i2c.c
    ../../../../../driver/board/mt25x3_hdk/bt_codec/src/: bt_a2dp_codec.c bt_hfp_codec.c
    ../../../../../middleware/MTK/audio/src/: audio_dsp_fd216_db_to_gain_value_mapping_table.c
  group gnss
    ../../../../../middleware/MTK/gnss/src/: gnss_api.c gnss_driver.c
  group hal
    ../../../../../driver/chip/mt2523/src/: hal_accdet.c hal_accdet_internal.c hal_adc.c hal_audio.c hal_audio_custom.c hal_audio_enhancement.c hal_audio_internal_afe.c hal_audio_internal_pcm.c hal_audio_internal_pcm2way.c hal_audio_internal_service.c hal_audio_internal_vm.c hal_audio_low_power.c hal_audio_post_processing.c hal_audio_test.c hal_bsi.c hal_cache.c hal_cache_internal.c hal_charger.c hal_dac.c hal_dcm.c hal_dcxo.c hal_display_color.c hal_display_color_internal.c hal_display_dsi.c hal_display_dsi_internal.c hal_display_lcd.c hal_display_lcd_internal.c hal_display_pwm.c hal_display_pwm_internal.c hal_dvfs.c hal_dvfs_internal.c hal_dvfs_internal_vcore.c hal_eint.c hal_eint_internal.c hal_emi.c hal_audio_fw_interface.c hal_audio_fw_slt.c hal_flash_cfi.c hal_flash_combo_init.c hal_flash_combo_nor.c hal_flash_custom.c hal_flash_custom_sfi.c hal_flash_disk.c hal_flash_mtd.c hal_flash_mtd_common.c hal_flash_mtd_dal.c hal_gdma.c hal_gdma_internal.c hal_gpio.c hal_gpt.c hal_gpt_internal.c hal_i2c_master.c hal_i2c_master_internal.c hal_i2c_pmic.c hal_i2s.c hal_i2s_internal.c hal_i2s_internal_pcm_route.c hal_isink.c hal_keypad.c hal_keypad_internal.c hal_keypad_powerkey_internal.c hal_log.c hal_misc.c hal_mpu.c hal_mpu_internal.c hal_msdc.c hal_nvic.c hal_dwt.c hal_nvic_internal.c hal_pdma_internal.c hal_pmu.c hal_pmu_auxadc.c hal_pmu_internal.c hal_pwm.c hal_rtc.c hal_sd.c hal_sd_internal.c hal_sdio.c hal_sdio_internal.c hal_spi_master.c hal_spi_master_internal.c hal_spi_slave.c hal_spi_slave_internal.c hal_trng.c hal_trng_internal.c hal_uart.c hal_uart_internal.c hal_uart_internal_platform.c hal_usb.c hal_usb_phy.c hal_wdt.c hal_wdt_internal.c hal_wdt_retention.c hal_weak.c hal_clock_internal.c hal_g2d.c hal_pmu_wrap_interface.c hal_aes.c
  group battery_management
    ../../../../../middleware/MTK/battery_management/port/mt2523/src/: battery_management_core.c battery_management_driver.c battery_management_meter.c
  group bt
    ../../../../../middleware/MTK/bluetooth/src/: bt_debug.c bt_hci_log.c bt_os_layer_api.c bt_task.c bt_task.h
  group third_party
    ../../../../../middleware/third_party/mbedtls/library/: aes.c md5.c
  group kservice
    ../../../../../kernel/service/src/: os_port_callback.c context_info_save.c exception_handler.c syslog.c toi.c
  group bt_sink
    ../../../../../middleware/MTK/bt_sink/src/: bt_sink_srv.c bt_sink_srv_a2dp.c bt_sink_srv_action.c bt_sink_srv_am_med_mgr.c bt_sink_srv_am_task.c bt_sink_srv_ami.c bt_sink_srv_atci_cmd.c bt_sink_srv_audio_tunning.c bt_sink_srv_avrcp.c bt_sink_srv_common.c bt_sink_srv_conmgr.c bt_sink_srv_custom_db.c bt_sink_srv_db.c bt_sink_srv_hf.c bt_sink_srv_hf_call_manager.c bt_sink_srv_hf_multipoint.c bt_sink_srv_music.c bt_sink_srv_pbapc.c bt_sink_srv_spp.c bt_sink_srv_state_notify.c bt_sink_srv_utils.c bt_sink_srv_audio_setting.c
  group bt_callback_manager
    ../../../../../middleware/MTK/bt_callback_manager/src/: bt_callback_manager.c
  group atci
    ../../../../../middleware/MTK/atci/src/: atci_adapter.c atci_handler.c atci_main.c
    ../../../../../middleware/MTK/atci/at_command/: at_command.c at_command_audio.c at_command_backlight.c at_command_bt.c at_command_camera.c at_command_charger.c at_command_clock.c at_command_crypto.c at_command_ctp.c at_command_dvfs.c at_command_external_gauge.c at_command_external_pmu.c at_command_gnss.c at_command_gpio.c at_command_gsensor.c at_command_keypad.c at_command_lcm.c at_command_led.c at_command_msdc.c at_command_nvdm.c at_command_pmu.c at_command_reg.c at_command_rtc.c at_command_sdkinfo.c at_command_sleep_manager.c at_command_syslog.c at_command_system.c at_command_vibrator.c at_command_wdt.c at_command_mem.c at_command_serial_port.c at_command_ctp_simulate.c at_command_keypad_simulate.c
  group fatfs
    ../../../../../middleware/third_party/fatfs/src/: ff.c
    ../../../../../middleware/third_party/fatfs/src/option/: syscall.c unicode.c
    ../../../../../middleware/third_party/fatfs/src/portable/mt2523/src/: diskio.c diskio_sd.c
  group mp3_codec
    ../../../../../middleware/MTK/audio/src/: audio_middleware_api.c audio_codec.c
    ../../../../../middleware/MTK/audio/mp3_codec/src/: mp3_codec.c
    ../../../../../middleware/MTK/audio/port/mt2523/src/: audio_nvdm.c
  group port_service
    ../../../../../middleware/MTK/port_service/src/: serial_port.c serial_port_para.c serial_port_uart.c serial_port_usb.c
  group usb
    ../../../../../middleware/MTK/usb/src/msc/: usbms_adap.c usbms_drv.c usbms_msdc.c usbms_state.c
    ../../../../../middleware/MTK/usb/src/cdc/: usbacm_adap.c usbacm_drv.c
    ../../../../../middleware/MTK/usb/src/_common/: usb.c usb_custom.c usb_main.c usb_resource.c
  group bluetooth_service
    ../../../../../middleware/MTK/bluetooth_service/src/: bt_device_manager.c
