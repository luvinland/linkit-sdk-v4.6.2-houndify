<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\modem_wifi5931_ref_design_wifi_only.ewp</path>
  </project>
  <batchBuild/>
</workspace>


