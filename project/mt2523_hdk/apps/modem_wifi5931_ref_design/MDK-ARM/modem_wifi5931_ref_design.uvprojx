# Keil uVision project modem_wifi5931_ref_design.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MT2523x MediaTek
  pack: MediaTek.MTx.4.6.2
  cpu: IROM(0x08000000,0x00400000) IRAM(0x00000000,0x00400000) IRAM2(0x04008000,0x00028000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: modem_wifi5931_ref_design +hex
  AfterMake: fromelf.exe --bin -o $L@L.bin #L
  AfterMake: fromelf.exe -c -o $L@L.dis #L
  c flags: Optim=4 OneElfS=1 wLevel=1
  c define: MTK_DEBUG_LEVEL_INFO, PRODUCT_VERSION=2523, MTK_SMART_BATTERY_ENABLE, MTK_PORT_SERVICE_ENABLE, MTK_ATCI_VIA_PORT_SERVICE, MTK_USB_DEMO_ENABLED, __MTK_TARGET__, MTK_BUILD_SMT_LOAD, MBEDTLS_CONFIG_FILE=<config-mtk-md5.h>, __BT_DEBUG__, MTK_NVDM_ENABLE, MTK_SYSTEM_AT_COMMAND_ENABLE, TCPIP_FOR_MT5931_ENABLE, BT_DEBUG, MTK_PORT_SERVICE_ENABLE, MTK_ATCI_VIA_PORT_SERVICE, MTK_WIFI_CHIP_USE_MT5931, MTK_DEVELOPMENT_BOARD_TYPE=EVB, MTK_PING_OUT_ENABLE, MTK_FW_VERSION=SDK_VER_IOT_SDK_DEV, MODEM_ENABLE, SUPPORT_MBEDTLS, MBEDTLS_CONFIG_FILE=<config-mtk-basic.h>, MTK_TCPIP_FOR_EXTERNAL_MODULE_ENABLE
  c misc: --c99;--cpu=Cortex-M4.fp --diag_error=47,68,111,177,174,188,223,550,1295
  c include: ..\inc;..\..\..\..\..\driver\CMSIS\Include;..\..\..\..\..\driver\CMSIS\Device\MTK\mt2523\Include;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\driver\chip\mt2523\inc;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\driver\board\component\common;..\..\..\..\..\driver\board\component\lcm\ST7789H2;..\inc\bt_audio;..\inc\bt_audio\sink;\..\..\..\..\..\middleware\MTK\bluetooth\inc;..\..\..\..\..\prebuilt\middleware\MTK\bluetooth\inc;..\..\..\..\..\middleware\MTK\nvdm\inc;..\..\..\..\..\middleware\MTK\atci\inc;..\inc\gnss_screen;..\inc\pxp_screen;..\inc\sensor_demo;..\inc\watch_face;..\..\..\..\..\driver\board\mt25x3_hdk\lcd;..\..\..\..\..\middleware\MTK\sensor_subsys\inc;..\..\..\..\..\driver\board\component\mems\inc;..\..\..\..\..\driver\board\component\mems\src\libyas533\inc;..\..\..\..\..\middleware\MTK\gnss\inc;..\..\..\..\..\driver\board\mt25x3_hdk\backlight;..\..\..\..\..\driver\board\mt25x3_hdk\keypad\inc;..\..\..\..\..\middleware\MTK\audio\inc;..\..\..\..\..\driver\board\component\biosensor\mt2511\inc;..\..\..\..\..\middleware\MTK\nvdm\inc;..\..\..\..\..\middleware\MTK\nvdm\src\nvdm_internal.h;..\..\..\..\..\middleware\MTK\nvdm\src\portable;..\..\..\..\..\driver\board\mt25x3_hdk\bt_codec\inc;..\..\..\..\..\middleware\MTK\gnss\inc;..\..\..\..\..\middleware\MTK\battery_management\port\mt2523\inc;..\..\..\..\..\middleware\MTK\battery_management\inc;..\..\..\..\..\driver\board\component\touch_panel\ctp_goodix_gt9xxx\gt9137;..\..\..\..\..\middleware\MTK\audio\inc;..\..\..\..\..\driver\board\component\touch_panel\common\inc;..\..\..\..\..\driver\board\mt25x3_hdk\touch_panel\gt9137;..\..\..\..\..\driver\board\mt25x3_hdk\touch_panel\it7258;..\..\..\..\..\driver\board\mt25x3_hdk\touch_panel\config;..\..\..\..\..\driver\board\component\touch_panel\ctp_ite_it7xxx\it7258;..\..\..\..\..\driver\board\component\biosensor\mt2511\inc;..\..\..\..\..\driver\board\component\biosensor\mt2511\module\default;..\..\..\..\..\driver\board\component\biosensor\mt2511\module\everlight;..\..\..\..\..\middleware\MTK\sensor_subsys\fusion_algo\common\inc;..\..\..\..\..\middleware\MTK\sensor_subsys\fusion_algo\heart_rate\inc;\..\..\..\..\..\middleware\MTK\sensor_subsys\fusion_algo\blood_pressure\inc;..\..\..\..\..\middleware\MTK\sensor_subsys\fusion_algo\ppg_control\inc;..\..\..\..\..\middleware\MTK\nvdm\inc_core;..\..\..\..\..\prebuilt\middleware\MTK\nvdm\inc;..\..\..\..\..\middleware\third_party\kiss_fft;..\..\..\..\..\middleware\MTK\port_service\inc;..\..\..\..\..\middleware\MTK\usb\inc;..\..\..\..\..\driver\board\mt25x3_hdk\ept\inc;..\..\..\..\..\middleware\third_party\kiss_fft;..\..\..\..\..\middleware\MTK\bt_sink\inc;..\..\..\..\..\middleware\third_party\mbedtls\include;..\..\..\..\..\middleware\third_party\mbedtls\include\mbedtls;..\..\..\..\..\middleware\third_party\mbedtls\configs;..\inc\main_screen;..\..\..\..\..\middleware\MTK\bt_callback_manager\inc;..\..\..\..\..\middleware\MTK\gdi\inc;..\inc\hogp;..\..\..\..\..\driver\board\mt25x3_hdk\mems_init;..\..\..\..\..\middleware\MTK\bluetooth_service\inc;..\..\..\..\..\middleware\MTK\audio\port\mt2523\inc;..\..\..\..\..\driver\board\mt25x3_hdk\wifi\mt5931\inc;..\..\..\..\..\middleware\third_party\httpclient\inc;..\..\..\..\..\middleware\third_party\lwip\src\include;..\..\..\..\..\middleware\third_party\lwip\ports\include;..\..\..\..\..\middleware\third_party\lwip\src\include\lwip;..\..\..\..\..\middleware\third_party\lwip\src\include\netif;..\..\..\..\..\middleware\MTK\nvdm\inc;..\..\..\..\..\middleware\MTK\minicli\inc;..\..\..\..\..\middleware\MTK\iperf\inc;..\..\..\..\..\driver\board\mt25x3_hdk\bt_codec\inc;..\..\..\..\..\driver\board\component\bt_codec\inc;..\inc\ept_common;..\..\..\..\..\driver\board\component\wifi\mt5931\inc;..\..\..\..\..\middleware\third_party\ping\inc;..\..\..\..\..\middleware\MTK\connsys\inc;..\..\..\..\..\middleware\MTK\dhcpd\inc;..\..\..\..\..\prebuilt\driver\board\component\bt_codec\inc;..\..\..\..\..\prebuilt\middleware\MTK\fuelgauge\inc;..\inc\modem_demo;..\inc\gnss_example;..\inc\fota_demo;..\..\..\..\..\middleware\third_party\mqtt\MQTTClient-C\src\mediatek;..\..\..\..\..\middleware\third_party\mqtt\MQTTPacket\src;..\..\..\..\..\middleware\third_party\mqtt\MQTTClient-C\src;..\..\..\..\..\middleware\MTK\sio\inc\msm;..\..\..\..\..\middleware\MTK\sio\inc\sio;..\..\..\..\..\middleware\MTK\sio\inc\sio_uart;..\..\..\..\..\middleware\MTK\sio\inc;..\..\..\..\..\middleware\third_party\mbedtls\include\mbedtls;..\..\..\..\..\middleware\third_party\mbedtls\configs;..\inc\gnss_example;..\..\..\..\..\middleware\MTK\gnss\inc;..\..\..\..\..\middleware\third_party\sntp\inc;..\..\..\..\..\middleware\MTK\fota\inc\internal;..\..\..\..\..\middleware\MTK\fota\inc;..\inc\fota_demo;..\..\..\..\..\driver\chip\mt7686\inc;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\prebuilt\middleware\MTK\slp\inc;..\..\..\..\..\middleware\MTK\verno\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT9: RAM 0x0 size 0x400000
  memory RVCT10: RAM 0x4008000 size 0x28000
  scatter file: .\flash.sct
  link misc: --entry Reset_Handler --first __Vectors
  group atci
    ../../../../../middleware/MTK/atci/src/: atci_main.c atci_adapter.c atci_handler.c
    ../src/: regions_init.c
    ../../../../../middleware/MTK/atci/at_command/: at_command.c at_command_audio.c at_command_backlight.c at_command_bt.c at_command_charger.c at_command_clock.c at_command_crypto.c at_command_ctp.c at_command_ctp_simulate.c at_command_dvfs.c at_command_external_gauge.c at_command_external_pmu.c at_command_gnss.c at_command_gpio.c at_command_gsensor.c at_command_keypad.c at_command_keypad_simulate.c at_command_lcm.c at_command_led.c at_command_mem.c at_command_msdc.c at_command_nvdm.c at_command_pmu.c at_command_reg.c at_command_rtc.c at_command_sdkinfo.c at_command_serial_port.c at_command_sleep_manager.c at_command_sys.c at_command_syslog.c at_command_system.c at_command_vibrator.c at_command_wdt.c
  group app
    ../src/ept_common/: ept_dte_eint_var.c ept_dte_gpio_var.c ept_eint_var.c ept_gpio_var.c
    ../src/: atci_cmd.c common.c gnss_cust.c hci_log.c lwip_network.c main.c task_def.c wifi_custom_config.c
  group cmsis
    ../src/: system_mt2523.c
    ./: startup_mt2523.s
  group kernel
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/RVDS/mt2523/: port_tick.c
    ../../../../../kernel/rtos/FreeRTOS/Source/: timers.c list.c queue.c tasks.c event_groups.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group hal
    ../../../../../driver/chip/mt2523/src/: hal_accdet.c hal_accdet_internal.c hal_adc.c hal_bsi.c hal_cache.c hal_cache_internal.c hal_charger.c hal_dac.c hal_dcm.c hal_dcxo.c hal_eint.c hal_eint_internal.c hal_emi.c hal_audio_fw_interface.c hal_audio_fw_slt.c hal_flash_cfi.c hal_flash_combo_init.c hal_flash_combo_nor.c hal_flash_custom.c hal_flash_custom_sfi.c hal_flash_disk.c hal_flash_mtd.c hal_flash_mtd_common.c hal_flash_mtd_dal.c hal_gdma.c hal_gdma_internal.c hal_gpio.c hal_gpt.c hal_gpt_internal.c hal_i2c_master.c hal_i2c_master_internal.c hal_i2c_pmic.c hal_i2s.c hal_i2s_internal.c hal_i2s_internal_pcm_route.c hal_isink.c hal_nvic.c hal_dwt.c hal_keypad.c hal_keypad_internal.c hal_keypad_powerkey_internal.c hal_log.c hal_mpu.c hal_mpu_internal.c hal_msdc.c hal_nvic_internal.c hal_pdma_internal.c hal_pmu.c hal_pmu_auxadc.c hal_pmu_internal.c hal_pwm.c hal_rtc.c hal_sd.c hal_sd_internal.c hal_sdio.c hal_sdio_internal.c hal_spi_master.c hal_spi_master_internal.c hal_spi_slave.c hal_spi_slave_internal.c hal_trng.c hal_trng_internal.c hal_uart.c hal_uart_internal.c hal_uart_internal_platform.c hal_wdt.c hal_wdt_internal.c hal_wdt_retention.c hal_audio.c hal_audio_enhancement.c hal_audio_internal_afe.c hal_audio_internal_pcm.c hal_audio_internal_pcm2way.c hal_audio_internal_service.c hal_audio_low_power.c hal_audio_test.c hal_audio_custom.c hal_audio_internal_vm.c hal_audio_post_processing.c hal_display_color.c hal_display_color_internal.c hal_display_dsi.c hal_display_dsi_internal.c hal_display_lcd.c hal_display_lcd_internal.c hal_display_pwm.c hal_display_pwm_internal.c hal_dvfs.c hal_misc.c hal_usb.c hal_usb_phy.c hal_weak.c hal_clock_internal.c hal_dvfs_internal_vcore.c hal_dvfs_internal.c hal_g2d.c hal_pmu_wrap_interface.c hal_aes.c
    ../../../../../prebuilt/driver/chip/mt2523/lib/: libhal_core_CM4_Keil.lib
  group gnss
    ../src/gnss_example/: epo_demo.c epo_download.c gnss_bridge_task.c gnss_demo.c gnss_ring_buffer.c gnss_test_cmd.c gnss_timer.c gnss_uart_bridge.c httpc_download_daem.c slp_app.c wepodownload.c gnss_app.c
    ../../../../../middleware/MTK/gnss/src/: gnss_api.c gnss_driver.c
    ../../../../../driver/board/mt25x3_hdk/gnss/: gnss_config.c
  group lib
    ../../../../../prebuilt/driver/chip/mt2523/lib/: libhal_protected_CM4_Keil.lib libcryptos_CM4_Keil.lib
    ../../../../../prebuilt/driver/board/mt25x3_hdk/wifi/mt5931/lib/: libwifibsp_CM4_KEIL.lib
    ../../../../../prebuilt/driver/board/component/wifi/mt5931/lib/: libwndrv_CM4_KEIL.lib
    ../../../../../prebuilt/middleware/MTK/minorsupc/lib/: libminorsupc_CM4_KEIL.lib
    ../../../../../prebuilt/middleware/MTK/fuelgauge/lib/: libfgauge.lib
    ../../../../../prebuilt/middleware/MTK/slp/lib/: libslp_Keil.lib
  group syslog
    ../../../../../kernel/service/src/: context_info_save.c exception_handler.c syslog.c toi.c os_port_callback.c
  group nvdm
    ../../../../../middleware/MTK/nvdm/src/: nvdm_port.c
    ../../../../../prebuilt/middleware/MTK/nvdm/lib/: libnvdm_CM4_KEIL.lib
  group board
    ../../../../../driver/board/mt25x3_hdk/ept/src/: bsp_gpio_ept_config.c
    ../../../../../driver/board/mt2523_band/keypad/src/: keypad_custom.c
    ../../../../../driver/board/mt25x3_hdk/backlight/: mt25x3_hdk_backlight.c
    ../../../../../driver/board/mt25x3_hdk/lcd/: mt25x3_hdk_lcd.c
    ../../../../../driver/board/component/lcm/RM69032/: lcd_RM69032.c
    ../../../../../driver/board/component/lcm/ST7789H2/: lcd.c
  group fota
    ../src/fota_demo/: fota_demo.c
    ../../../../../middleware/MTK/fota/src/: fota.c
    ../../../../../middleware/MTK/fota/src/internal/: fota_config.c fota_internal.c fota_port.c
  group modem
    ../src/modem_demo/: gprs_api.c nw_app_main.c nw_atci.c
    ../../../../../middleware/MTK/sio/src/msm/: msm_eint.c msm_gpio.c
    ../../../../../middleware/MTK/sio/src/sio/: sio_main.c
    ../../../../../middleware/MTK/sio/src/sio_uart/: sio_uart_adapter.c sio_uart_main.c sio_uart_port.c sio_uart_ut.c
    ../../../../../middleware/MTK/sio/src/: urc_app.c
  group lwip
    ../../../../../middleware/third_party/lwip/ports/: lwip_cli.c lwip_log.c mt5931_netif.c pbuf.c psnetif.c sys_arch.c tcp_out.c
    ../../../../../middleware/third_party/lwip/src/api/: tcpip.c sockets.c netifapi.c netdb.c netbuf.c err.c api_msg.c api_lib.c pppapi.c
    ../../../../../middleware/third_party/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c ip_frag.c ip4.c ip4_addr.c
    ../../../../../middleware/third_party/lwip/src/core/: def.c dhcp.c dns.c inet_chksum.c init.c lwip_timers.c mem.c memp.c netif.c raw.c stats.c sys.c tcp.c tcp_in.c udp.c
    ../../../../../middleware/third_party/lwip/src/netif/: etharp.c ethernetif.c slipif.c
  group sntp
    ../../../../../middleware/third_party/sntp/src/: sntp.c
  group mqtt
    ../../../../../middleware/third_party/mqtt/MQTTClient-C/src/: MQTTClient.c
    ../../../../../middleware/third_party/mqtt/MQTTClient-C/src/mediatek/: MQTTMediatek.c
    ../../../../../middleware/third_party/mqtt/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group http
    ../../../../../middleware/third_party/httpclient/src/: httpclient.c
  group iperf
    ../../../../../middleware/MTK/iperf/src/: iperf_task.c
  group ping
    ../../../../../middleware/third_party/ping/src/: ping.c
  group usb
    ../../../../../middleware/MTK/usb/src/_common/: usb.c usb_custom.c usb_main.c usb_resource.c
    ../../../../../middleware/MTK/usb/src/cdc/: usbacm_adap.c usbacm_drv.c
    ../../../../../middleware/MTK/usb/src/msc/: usbms_adap.c usbms_drv.c usbms_msdc.c usbms_state.c
  group port service
    ../../../../../middleware/MTK/port_service/src/: serial_port.c serial_port_para.c serial_port_uart.c serial_port_usb.c
  group mbedtls
    ../../../../../middleware/third_party/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c cmac.c ecjpake.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group battery_manager
    ../../../../../middleware/MTK/battery_management/port/mt2523/src/: battery_management_core.c battery_management_driver.c battery_management_meter.c
