# Keil uVision project watch_ref_design.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MT2523x MediaTek
  pack: MediaTek.MTx.4.6.2
  cpu: IROM(0x08000000,0x00400000) IRAM(0x00000000,0x00400000) IRAM2(0x04008000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: watch_ref_design
  AfterMake: fromelf.exe --bin -o $L@L.bin #L
  AfterMake: fromelf.exe -c -o $L@L.dis #L
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: MTK_DEBUG_LEVEL_INFO PRODUCT_VERSION=2523 MTK_SENSOR_BIO_USE MTK_SENSOR_BIO_USE_MT2511 MT2511_USE_SPI USE_EXTERNAL_BOOST MTK_SENSOR_ACCELEROMETER_GYROSCOPE_USE MTK_SENSOR_ACCELEROMETER_GYROSCOPE_USE_ICM30630 FUSION_HEART_RATE_MONITOR_USE=M_INHOUSE_HEART_RATE_MONITOR FUSION_BLOOD_PRESSURE_USE=M_INHOUSE_BLOOD_PRESSURE FUSION_PEDOMETER_USE=ICM_PEDOMETER SENSOR_FUSTION_TASK_ENABLED SENSOR_DEMO MTK_USB_DEMO_ENABLED __USB_MASS_STORAGE_ENABLE__ MTK_NVDM_ENABLE MTK_CTP_ENABLE,__BT_DEBUG__,MBEDTLS_CONFIG_FILE=<config-mtk-md5.h>  DYNAMIC_BITMAP_LOADER MTK_AT_CMD_DISABLE MTK_PORT_SERVICE_ENABLE MTK_ATCI_VIA_PORT_SERVICE MTK_AT_CMD_DISABLE UI_TOUCHGFX WATCH_DRIVER_DRIVER_V2 FUSION_REPORT_RAW_DATA_ENABLE SHOW_UCS2 MTK_AUDIO_MP3_ENABLED MTK_BT_A2DP_SOURCE_ENABLE MTK_BT_CODEC_ENABLED MTK_BT_A2DP_ENABLE MTK_BT_AVRCP_ENABLE MTK_BT_AVRCP_ENH_ENABLE MTK_BT_A2DP_SOURCE_SUPPORT
  c include: ..\..\..\..\..\project\mt2523_watch\apps\watch_ref_design\src\ui\gui\include;..\..\..\..\..\project\mt2523_watch\apps\watch_ref_design\src\ui\gui\include\gui\common;..\inc;..\..\..\..\..\driver\CMSIS\Device\MTK\mt2523\Include;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\driver\chip\mt2523\inc;..\..\..\..\..\driver\CMSIS\Include;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\driver\board\mt2523_watch\mems_init;..\..\..\..\..\driver\board\mt2523_watch\lcd;..\..\..\..\..\driver\board\mt2523_watch\backlight;..\..\..\..\..\driver\board\mt25x3_hdk\ept\inc;..\..\..\..\..\middleware\MTK\nvdm\inc;..\..\..\..\..\middleware\third_party\touchgfx\inc;..\..\..\..\..\middleware\third_party\touchgfx\inc\touchgfx;..\..\..\..\..\middleware\third_party\touchgfx\inc\touchgfx/hal;..\..\..\..\..\project\mt2523_watch\apps\watch_ref_design\src\ui\gui\include\gui\home_screen;..\..\..\..\..\project\mt2523_watch\apps\watch_ref_design\src\ui\gui\include\gui\main_menu_screen;..\..\..\..\..\project\mt2523_watch\apps\watch_ref_design\src\ui\gui\include\gui\setting_screen;..\..\..\..\..\project\mt2523_watch\apps\watch_ref_design\src\ui\gui\include\gui\graph_screen;..\..\..\..\..\project\mt2523_watch\apps\watch_ref_design\src\ui\gui\include\gui\model;..\..\..\..\..\project\mt2523_watch\apps\watch_ref_design\src\ui\gui\include\gui\database;..\..\..\..\..\project\mt2523_watch\apps\watch_ref_design\src\generated\fonts\include;..\..\..\..\..\project\mt2523_watch\apps\watch_ref_design\src\generated\images\include;..\..\..\..\..\project\mt2523_watch\apps\watch_ref_design\src\generated\texts\include;..\..\..\..\..\project\mt2523_watch\apps\watch_ref_design\inc\sensor_demo;..\..\..\..\..\driver\board\component\mems\inc;..\..\..\..\..\driver\board\component\biosensor\mt2511\inc;..\..\..\..\..\driver\board\component\biosensor\mt2511\module\solteamopto;..\..\..\..\..\middleware\MTK\sensor_subsys\inc;..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\common\inc;..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\heart_rate\inc;..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\ppg_control\inc;..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\blood_pressure\inc;..\..\..\..\..\driver\board\component\common;..\..\..\..\..\driver\board\component\touch_panel\common\inc;..\..\..\..\..\driver\board\component\component\touch_panel\ctp_ite_it7xxx\it7258;..\..\..\..\..\driver\board\mt2523_watch\keypad\inc;..\..\..\..\..\driver\board\mt2523_watch\touch_panel\config;..\..\..\..\..\driver\board\mt2523_watch\touch_panel\it7258;..\..\..\..\..\middleware\MTK\gnss\inc;..\inc\gnss_demo;..\..\..\..\..\middleware\MTK\usb\inc;..\..\..\..\..\middleware\MTK\battery_management\inc;..\..\..\..\..\middleware\MTK\battery_management\port\mt2523\inc;..\..\..\..\..\prebuilt\middleware\MTK\fuelgauge\inc;..\inc\Notification;..\..\..\..\..\middleware\MTK\bluetooth\inc;..\..\..\..\..\prebuilt\middleware\MTK\bluetooth\inc;..\..\..\..\..\middleware\MTK\ble_ancs\inc;..\..\..\..\..\prebuilt\middleware\MTK\ble_ancs\inc;..\..\..\..\..\middleware\MTK\bt_notify\inc\dogp;..\..\..\..\..\middleware\MTK\bt_notify\inc;..\..\..\..\..\middleware\MTK\bt_callback_manager\inc;..\..\..\..\..\middleware\third_party\mbedtls\configs;..\..\..\..\..\middleware\third_party\mbedtls\include;..\..\..\..\..\middleware\third_party\lzma_decoder\inc;..\..\..\..\..\middleware\MTK\port_service\inc;..\inc\ble_find_me_client;..\..\..\..\..\middleware\MTK\bluetooth_service\inc;..\src\dt\inc;..\..\..\..\..\middleware\MTK\atci\inc;..\..\..\..\..\driver\board\component\mems\src\icm30630;..\..\..\..\..\driver\board\component\mems\src\icm30630\image;..\..\..\..\..\driver\board\component\mems\src\icm30630\Invn\Devices;..\inc\bt_connection;..\inc\AudioPlayer;..\..\..\..\..\middleware\MTK\verno\inc;..\..\..\..\..\middleware\MTK\bt_source\inc;..\..\..\..\..\middleware\third_party\fatfs\src;..\..\..\..\..\middleware\MTK\bt_sink\inc;..\..\..\..\..\middleware\third_party\fatfs\src\portable\mt2523\inc;..\..\..\..\..\middleware\MTK\audio\port\mt2523\inc;..\..\..\..\..\middleware\MTK\audio\mp3_codec\inc;..\..\..\..\..\middleware\MTK\audio\sbc_codec\inc;..\..\..\..\..\prebuilt\driver\board\component\audio\inc;..\..\..\..\..\prebuilt\driver\board\component\bt_codec\inc;..\..\..\..\..\middleware\MTK\audio\inc;..\..\..\..\..\driver\board\mt25x3_hdk\bt_codec\inc;..\inc\AudioPlayer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT9: RAM 0x0 size 0x400000
  memory RVCT10: RAM 0x4008000 size 0x20000
  scatter file: .\flash.sct
  link misc: --entry Reset_Handler --first __Vectors
  group app
    ../src/sensor_demo/: sensor_demo.c
    ../src/gnss_demo/: epo_demo.c gnss_app.c gnss_ring_buffer.c gnss_timer.c gnss_bridge_task.c gnss_uart_bridge.c
    ../src/: bt_init.c ept_eint_var.c ept_gpio_var.c gatt_service.c sys_init.c regions_init.c bt_app_common.c bt_gattc_discovery.c hci_log.c
  group driver
    ../../../../../driver/chip/mt2523/src/: hal_nvic_internal.c hal_nvic.c hal_dwt.c hal_gpio.c hal_uart_internal_platform.c hal_uart.c hal_uart_internal.c hal_flash_mtd_common.c hal_flash_mtd_dal.c hal_flash_cfi.c hal_flash_combo_init.c hal_flash_combo_nor.c hal_flash_custom.c hal_flash_custom_sfi.c hal_flash_disk.c hal_flash_mtd.c hal_gpt_internal.c hal_gpt.c hal_weak.c hal_emi.c hal_log.c hal_pdma_internal.c hal_clock_internal.c hal_i2c_master.c hal_i2c_master_internal.c hal_spi_master.c hal_spi_master_internal.c hal_usb.c hal_usb_phy.c hal_display_color.c hal_display_color_internal.c hal_display_dsi.c hal_display_dsi_internal.c hal_display_lcd.c hal_display_lcd_internal.c hal_display_pwm.c hal_display_pwm_internal.c hal_g2d.c hal_gdma.c hal_gdma_internal.c hal_i2c_pmic.c hal_i2s.c hal_i2s_internal.c hal_i2s_internal_pcm_route.c hal_isink.c hal_keypad.c hal_keypad_internal.c hal_keypad_powerkey_internal.c hal_misc.c hal_mpu.c hal_mpu_internal.c hal_msdc.c hal_pmu.c hal_pmu_auxadc.c hal_pmu_internal.c hal_pmu_wrap_interface.c hal_pwm.c hal_rtc.c hal_sd.c hal_sd_internal.c hal_sdio.c hal_sdio_internal.c hal_spi_slave.c hal_spi_slave_internal.c hal_trng.c hal_trng_internal.c hal_wdt.c hal_wdt_internal.c hal_wdt_retention.c hal_accdet.c hal_accdet_internal.c hal_adc.c hal_cache.c hal_cache_internal.c hal_charger.c hal_dac.c hal_eint.c hal_eint_internal.c hal_dvfs.c hal_dvfs_internal.c hal_dvfs_internal_vcore.c hal_audio.c hal_audio_custom.c hal_audio_enhancement.c hal_audio_ext.c hal_audio_fw_interface.c hal_audio_fw_slt.c hal_audio_internal_afe.c hal_audio_internal_pcm.c hal_audio_internal_pcm2way.c hal_audio_internal_service.c hal_audio_internal_vm.c hal_audio_low_power.c hal_audio_post_processing.c hal_dcxo.c
  group cmsis
    ./: startup_mt2523.s
    ../src/: system_mt2523.c
  group kernel
    ../../../../../kernel/rtos/FreeRTOS/Source/: tasks.c timers.c list.c queue.c croutine.c event_groups.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/RVDS/mt2523/: port_tick.c
  group lib
    ../../../../../prebuilt/driver/chip/mt2523/lib/: libhal_core_CM4_Keil.lib libhal_protected_CM4_Keil.lib
    ../../../../../middleware/third_party/touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib
    ../../../../../prebuilt/middleware/MTK/bluetooth/lib/: libbt_CM4_keil.lib libbt_spp_CM4_keil.lib libbtdriver_2523_CM4_keil.lib libbt_a2dp_CM4_keil.lib libbt_avrcp_eh_CM4_keil.lib libbt_avrcp_CM4_keil.lib libbt_hfp_CM4_keil.lib libbt_pbapc_CM4_keil.lib
    ../../../../../prebuilt/middleware/MTK/ble_ancs/lib/: libbleancs_Keil.lib
    ../../../../../prebuilt/middleware/MTK/bt_notify/lib/: libbtnotify_Keil.lib
    ../../../../../prebuilt/middleware/MTK/fuelgauge/lib/: libfgauge.lib
    ../../../../../prebuilt/middleware/MTK/audio/mp3_codec/lib/arm_cm4/: lib_mp3dec_CM4_Keil.lib
    ../../../../../prebuilt/driver/board/component/audio/lib/arm_cm4/: libblisrc_CM4_Keil.lib
    ../../../../../prebuilt/driver/board/component/bt_codec/lib/arm_cm4/: libcvsd_codec_CM4_Keil.lib libmsbc_codec_CM4_Keil.lib libplc_CM4_Keil.lib
    ../../../../../middleware/MTK/audio/sbc_codec/lib/arm_cm4/: libsbc_encoder_CM4_Keil.lib
  group kservice
    ../../../../../kernel/service/src/: context_info_save.c exception_handler.c syslog.c toi.c os_port_callback.c
  group sensor_subsys
    ../../../../../middleware/MTK/sensor_subsys/src/: sensor_manager.c
  group sensor_fusion
    ../../../../../middleware/MTK/sensor_subsys/src/algo_adaptor/: algo_adaptor.c heart_rate_monitor_adaptor.c blood_pressure_monitor_adaptor.c icm_pedometer_adaptor.c
    ../../../../../prebuilt/middleware/MTK/fusion_algo/common/lib_core/: libcomm_CM4_KEIL.lib
    ../../../../../prebuilt/middleware/MTK/fusion_algo/heart_rate/lib_core/: libhr_CM4_KEIL.lib
    ../../../../../prebuilt/middleware/MTK/fusion_algo/ppg_control/lib_core/: libppgctrl_CM4_KEIL.lib
    ../../../../../prebuilt/middleware/MTK/fusion_algo/blood_pressure/lib_core/: libbp_CM4_Keil.lib
    ../../../../../prebuilt/middleware/MTK/fusion_algo/ppg_control/module/solteamopto/: ppg_control_module.c
  group mems
    ../../../../../driver/board/component/mems/src/: bma2x2.c bma255_i2c_operation.c bma255_sensor_adaptor.c mems_bus.c sensor_manager_driver.c icm30630.c
    ../../../../../driver/board/mt2523_watch/mems_init/: mems_init.c
    ../../../../../driver/board/component/biosensor/mt2511/src/: vsm_driver.c vsm_i2c_operation.c vsm_platform_function.c vsm_sensor_subsys_adaptor.c vsm_spi_operation.c
    ../../../../../driver/board/component/mems/src/icm30630/Invn/Devices/: DeviceIcm30xxx.c
    ../../../../../driver/board/component/mems/src/icm30630/Invn/Devices/Drivers/Icm30xxx/: Icm30xxxCmd.c Icm30xxxCtrl.c Icm30xxxFifo.c Icm30xxxLoad.c Icm30xxxLogger.c Icm30xxxSelfTest.c Icm30xxxSetup.c Icm30xxxTransport.c
    ../../../../../driver/board/component/mems/src/icm30630/Invn/EmbUtils/: DataConverter.c
    ../../../../../driver/board/component/mems/src/icm30630/Invn/FifoProtocol/: FifoProtocolCore.c
  group touchgfxHAL
    ../../../../../middleware/third_party/touchgfx/src/: CortexMMCUInstrumentation.cpp GPIO.cpp mt2523DMA.cpp mt2523HAL.cpp OSWrappers.cpp
  group gui
    ../src/ui/gui/src/common/: CommonService.cpp DemoPresenter.cpp FrontendApplication.cpp
    ../src/ui/gui/src/home_screen/: HomePresenter.cpp HomeView.cpp NotificationListPresenter.cpp NotificationListView.cpp MassStoragePresenter.cpp MassStorageView.cpp
    ../src/ui/gui/src/main_menu_screen/: DotIndicator.cpp MainMenuPresenter.cpp MainMenuView.cpp SwipeContainer.cpp
    ../src/ui/gui/src/setting_screen/: DatePicker.cpp HorizontalSlideMenu.cpp MenuListElement.cpp ScreenTimeoutPresenter.cpp ScreenTimeoutView.cpp SetBluetoothPresenter.cpp SetBluetoothView.cpp SetClockPresenter.cpp SetClockView.cpp SetDatePresenter.cpp SetDateView.cpp SetGPSPresenter.cpp SetGPSView.cpp SetHeartRatePresenter.cpp SetHeartRateView.cpp SetTimePresenter.cpp SetTimeView.cpp SettingPresenter.cpp SettingView.cpp TimePicker.cpp WheelSelector.cpp WheelSelectorExtra.cpp SetUSBModePresenter.cpp SetUSBModeView.cpp BTDeviceListPresenter.cpp BTDeviceListView.cpp BTDeviceOpPresenter.cpp BTDeviceOpView.cpp BTDeviceSearchListView.cpp BTDeviceSerachListPresenter.cpp
    ../src/ui/gui/src/graph_screen/: AbstractGraph.cpp Graph.cpp GraphBelow.cpp GraphDots.cpp GraphLine.cpp PainterColoredBitmap.cpp PainterVerticalAlpha.cpp
    ../src/ui/gui/src/model/: Model.cpp
    ../src/ui/gui/src/database/: heart_rate_db.cpp
    ../src/touch_adapter/: mt2523TouchController.cpp
  group board
    ../../../../../driver/board/mt2523_watch/touch_panel/it7258/: touch_panel_custom_ite.c
    ../../../../../driver/board/mt2523_watch/backlight/: mt25x3_hdk_backlight.c
    ../../../../../driver/board/mt2523_watch/lcd/: mt25x3_hdk_lcd.c
    ../../../../../driver/board/component/lcm/RM69080/: lcd_RM69080.c
    ../../../../../driver/board/mt2523_watch/keypad/src/: keypad_custom.c
    ../../../../../driver/board/component/touch_panel/common/src/: bsp_ctp.c ctp.c ctp_i2c.c
    ../../../../../driver/board/component/touch_panel/ctp_ite_it7xxx/it7258/: ctp_ite_it7xxx.c ctp_ite_it7xxx_download.c
    ../../../../../driver/board/mt25x3_hdk/ept/src/: bsp_gpio_ept_config.c
    ../../../../../driver/board/component/lcm/RM67160/: lcd_RM67160.c
  group gnss
    ../../../../../middleware/MTK/gnss/src/: gnss_api.c gnss_driver.c
    ../../../../../driver/board/mt25x3_hdk/gnss/: gnss_config.c
  group usb
    ../../../../../middleware/MTK/usb/src/_common/: usb.c usb_custom.c usb_main.c usb_resource.c
    ../../../../../middleware/MTK/usb/src/msc/: usbms_adap.c usbms_drv.c usbms_msdc.c usbms_state.c
    ../../../../../middleware/MTK/usb/src/cdc/: usbacm_drv.c usbacm_adap.c
  group nvdm
    ../../../../../middleware/MTK/nvdm/src/: nvdm_port.c
    ../../../../../prebuilt/middleware/MTK/nvdm/lib/: libnvdm_CM4_KEIL.lib
  group Bluetooth
    ../../../../../middleware/MTK/bluetooth/src/: bt_debug.c bt_hci_log.c bt_os_layer_api.c bt_task.c
    ../../../../../middleware/third_party/mbedtls/library/: aes.c md5.c
  group bt_callback_manager
    ../../../../../middleware/MTK/bt_callback_manager/src/: bt_callback_manager.c
  group bt_notify_service
    ../../../../../middleware/MTK/bt_notify/src/: bt_notify_conversion.c bt_notify_data_parse.c bt_notify_list.c bt_notify_task.c xml_main.c
  group dogp_service
    ../../../../../middleware/MTK/bt_notify/src/dogp/: ble_dogp_adp_service.c ble_dogp_common.c ble_dogp_service.c
  group generated_texts
    ../src/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group app_enter
    ../src/: main.cpp
    ../src/ui/gui/src/: BoardConfiguration.cpp
  group notification
    ../src/Notification/: ble_ancs_app.c bt_ancs_common.c bt_notify_app.c bt_notify_app_list.c
  group battery_management
    ../../../../../middleware/MTK/battery_management/port/mt2523/src/: battery_management_core.c battery_management_driver.c battery_management_meter.c
  group battery
    ../src/battery/: battery_message.c
  group generated_images
    ../src/generated/images/src/Home/: icon_android.int.cpp icon_battery.int.cpp icon_battery_charging.int.cpp icon_battery_charging_small.int.cpp icon_battery_small.int.cpp icon_ios.int.cpp clock_hour_hand.int.cpp clock_minute_hand.int.cpp clock_second_hand.int.cpp compound_clock_hour_hand.int.cpp compound_clock_minute_hand.int.cpp compound_clock_second_hand.int.cpp compound_clock_center_dot.int.cpp
    ../src/generated/images/src/MainMenu/: icon_large_heart.int.cpp icon_small_heart.int.cpp screen_swipe_dots_active.int.cpp screen_swipe_dots_inactive.int.cpp
    ../src/generated/images/src/Setting/: datepicker_glass_overlay.int.cpp list_icon_0.int.cpp list_icon_1.int.cpp list_icon_2.int.cpp list_icon_3.int.cpp list_icon_4.int.cpp list_icon_5.int.cpp list_icon_6.int.cpp list_icon_7.int.cpp list_menu_overlay.int.cpp timepicker_glass_overlay.int.cpp bg_btconnection_item_newdevice.int.cpp
    ../src/generated/images/src/: BitmapDatabase.cpp
    ../src/generated/images/src/Player/: player_add_circle.int.cpp player_add_circle_disable.int.cpp player_remove_circle.int.cpp player_remove_circle_disable.int.cpp player_volume.int.cpp player_volume_off.int.cpp
  group generated_dynamic_images
    ../src/generated/dynamic_images/src/ClockStyle/: clockstyle_clock1_active.cpp clockstyle_clock1_inactive.cpp clockstyle_clock2_active.cpp clockstyle_clock2_inactive.cpp clockstyle_clock3_active.cpp clockstyle_clock3_inactive.cpp
    ../src/generated/dynamic_images/src/Home/: common_background.cpp home_clock_background.cpp home_compound_clock_background.cpp icon_usb.cpp
    ../src/generated/dynamic_images/src/MainMenu/: menu_fmp.cpp menu_gps.cpp menu_setting.cpp fmp_start_long.cpp fmp_stop_long.cpp
    ../src/generated/dynamic_images/src/Setting/: datepicker_background.cpp list_menu_background.cpp switch_off.cpp switch_on.cpp timepicker_background.cpp btn_cancel_long.cpp btn_cancel_short.cpp btn_yes_short.cpp
    ../src/ui/gui/src/database/: DynamicBitmapDatabase.cpp
    ../src/generated/dynamic_images/src/Player/: player_pause.cpp player_play.cpp player_skip_next.cpp player_skip_previous.cpp player_volume_1.cpp player_volume_2.cpp player_volume_3.cpp player_volume_4.cpp player_volume_5.cpp player_volume_6.cpp player_volume_7.cpp player_volume_background.cpp
  group lzma_decoder
    ../../../../../middleware/third_party/lzma_decoder/src/: lzma_decode_interface.c lzma_decoder.c
  group port_service
    ../../../../../middleware/MTK/port_service/src/: serial_port.c serial_port_para.c serial_port_uart.c serial_port_usb.c
  group ble_find_me_client
    ../src/ble_find_me_client/: ble_find_me_client.c
  group bluetooth_service
    ../../../../../middleware/MTK/bluetooth_service/src/: bt_device_manager_le.c bt_gatts_service.c bt_device_manager.c
  group sensor_dt
    ../src/dt/src/: data_transfer.c
  group atci
    ../../../../../middleware/MTK/atci/src/: atci_main.c atci_adapter.c atci_handler.c
    ../../../../../middleware/MTK/atci/at_command/: at_command.c
  group bt_connection
    ../src/bt_connection/: bt_connection_app.cpp
  group generated_fonts
    ../src/generated/fonts/src/: ApplicationFontProvider.cpp Font_MavenPro_Medium_28_4bpp.cpp Font_RobotoCondensed_Regular_14_4bpp.cpp Font_RobotoCondensed_Regular_24_4bpp.cpp Font_RobotoCondensed_Regular_28_4bpp.cpp Font_RobotoCondensed_Regular_30_4bpp.cpp Font_RobotoCondensed_Regular_32_4bpp.cpp Font_RobotoCondensed_Regular_35_4bpp.cpp Font_RobotoCondensed_Regular_70_4bpp.cpp Font_RobotoCondensed_Regular_120_4bpp.cpp FontGetters.cpp Kerning_MavenPro_Medium_28_4bpp.cpp Kerning_RobotoCondensed_Regular_14_4bpp.cpp Kerning_RobotoCondensed_Regular_24_4bpp.cpp Kerning_RobotoCondensed_Regular_28_4bpp.cpp Kerning_RobotoCondensed_Regular_30_4bpp.cpp Kerning_RobotoCondensed_Regular_32_4bpp.cpp Kerning_RobotoCondensed_Regular_35_4bpp.cpp Kerning_RobotoCondensed_Regular_70_4bpp.cpp Kerning_RobotoCondensed_Regular_120_4bpp.cpp Table_MavenPro_Medium_28_4bpp.cpp Table_RobotoCondensed_Regular_14_4bpp.cpp Table_RobotoCondensed_Regular_24_4bpp.cpp Table_RobotoCondensed_Regular_28_4bpp.cpp Table_RobotoCondensed_Regular_30_4bpp.cpp Table_RobotoCondensed_Regular_32_4bpp.cpp Table_RobotoCondensed_Regular_35_4bpp.cpp Table_RobotoCondensed_Regular_70_4bpp.cpp Table_RobotoCondensed_Regular_120_4bpp.cpp
  group audio_player
    ../src/AudioPlayer/: audio_player_main.c
  group fatfs
    ../../../../../middleware/third_party/fatfs/src/: ff.c
    ../../../../../middleware/third_party/fatfs/src/option/: syscall.c unicode.c
    ../../../../../middleware/third_party/fatfs/src/portable/mt2523/src/: diskio.c diskio_sd.c diskio_snand.c
  group bt_source
    ../../../../../middleware/MTK/bt_source/src/: bt_source_srv.c bt_source_srv_a2dp.c bt_source_srv_avrcp.c bt_source_srv_cntx.c bt_source_srv_utils.c
  group bt_sink
    ../../../../../middleware/MTK/bt_sink/src/: bt_sink_srv.c bt_sink_srv_a2dp.c bt_sink_srv_action.c bt_sink_srv_am_med_mgr.c bt_sink_srv_am_task.c bt_sink_srv_ami.c bt_sink_srv_atci_cmd.c bt_sink_srv_audio_sync.c bt_sink_srv_audio_tunning.c bt_sink_srv_avrcp.c bt_sink_srv_aws.c bt_sink_srv_common.c bt_sink_srv_conmgr.c bt_sink_srv_custom_db.c bt_sink_srv_db.c bt_sink_srv_hf.c bt_sink_srv_hf_call_manager.c bt_sink_srv_hf_multipoint.c bt_sink_srv_music.c bt_sink_srv_pbapc.c bt_sink_srv_spp.c bt_sink_srv_state_notify.c bt_sink_srv_utils.c bt_sink_srv_audio_setting.c
  group audio
    ../../../../../middleware/MTK/audio/src/: audio_codec.c audio_middleware_api.c audio_dsp_fd216_db_to_gain_value_mapping_table.c
    ../../../../../middleware/MTK/audio/port/mt2523/src/: audio_nvdm.c
    ../../../../../middleware/MTK/audio/mp3_codec/src/: mp3_codec.c
    ../../../../../middleware/MTK/audio/sbc_codec/src/: sbc_codec.c
  group bt_codec
    ../../../../../driver/board/mt25x3_hdk/bt_codec/src/: bt_a2dp_codec.c bt_hfp_codec.c
